options:
  parameters:
    author: Frank Fu
    generate_options: no_gui
    id: bpskrxtx
    output_language: python
    title: BPSK RX TX Backend
  states: {}

blocks:
- name: constel
  id: variable_constellation
  parameters:
    precision: '8'
    type: bpsk
  states: {}
- name: freq_offset
  id: variable_qtgui_range
  parameters:
    gui_hint: '[0, 1, 1, 1]'
    label: Freq Offset
    start: '-0.25'
    step: '0.001'
    stop: '0.25'
    value: '0.01'
  states: {state: disabled}
- name: hdr
  id: variable
  parameters:
    value: digital.header_format_default(digital.packet_utils.default_access_code, 0)
  states: {}
- name: noise
  id: variable_qtgui_range
  parameters:
    gui_hint: '[0, 0, 1, 1]'
    label: Noise
    start: '0.0'
    step: '0.01'
    stop: '2.0'
    value: '0.1'
  states: {state: disabled}
- name: payload_size
  id: variable
  parameters:
    value: '1024'
  states: {}
- name: postamble_size
  id: variable
  parameters:
    value: '10000'
  states: {}
- name: preamble_size
  id: variable
  parameters:
    value: '250'
  states: {}
- name: rx_freq
  id: variable
  parameters:
    value: 925e6
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 200e3
  states: {}
- name: sps
  id: variable
  parameters:
    value: '4'
  states: {}
- name: time_offset
  id: variable_qtgui_range
  parameters:
    gui_hint: '[0, 2, 1, 1]'
    label: Time Scale
    start: '0.999'
    step: '0.0001'
    stop: '1.001'
    value: '1.0001'
  states: {state: disabled}
- name: tx_freq
  id: variable
  parameters:
    value: 915e6
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: bpsk_receive.txt
    type: byte
    unbuffered: 'True'
  states: {state: disabled}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: bpsk_transmit.txt
    repeat: 'False'
    type: byte
  states: {state: disabled}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {state: disabled}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '0.5'
    type: complex
  states: {}
- name: blocks_repack_bits_bb_1
  id: blocks_repack_bits_bb
  parameters:
    align_output: 'True'
    endianness: gr.GR_MSB_FIRST
    k: '1'
    l: '8'
    len_tag_key: packet_len
  states: {}
- name: blocks_stream_to_tagged_stream_0
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: '"packet_len"'
    packet_len: int(payload_size)
    type: byte
  states: {}
- name: blocks_stream_to_tagged_stream_0_0_0
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: '"packet_len"'
    packet_len: payload_size
    type: byte
  states: {state: disabled}
- name: blocks_stream_to_tagged_stream_0_0_0_0
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: '"packet_len"'
    packet_len: preamble_size
    type: byte
  states: {}
- name: blocks_stream_to_tagged_stream_0_0_0_0_0
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: '"packet_len"'
    packet_len: postamble_size
    type: byte
  states: {}
- name: blocks_tag_gate_0
  id: blocks_tag_gate
  parameters:
    propagate_tags: 'False'
    type: complex
  states: {}
- name: blocks_tagged_stream_mux_0
  id: blocks_tagged_stream_mux
  parameters:
    lengthtagname: packet_len
    ninputs: '4'
    type: byte
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {state: disabled}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    comment: Preamble
    repeat: 'True'
    type: byte
    vector: '[0xc0, 0xaf]'
  states: {}
- name: blocks_vector_source_x_0_0
  id: blocks_vector_source_x
  parameters:
    comment: Postamble
    repeat: 'True'
    type: byte
    vector: '[0xc0, 0xaf]'
  states: {}
- name: digital_constellation_decoder_cb_1
  id: digital_constellation_decoder_cb
  parameters:
    constellation: constel
  states: {}
- name: digital_constellation_modulator_0
  id: digital_constellation_modulator
  parameters:
    constellation: constel
    differential: 'True'
    excess_bw: '0.35'
    samples_per_symbol: sps
  states: {}
- name: digital_correlate_access_code_xx_ts_0
  id: digital_correlate_access_code_xx_ts
  parameters:
    access_code: digital.packet_utils.default_access_code
    tagname: packet_len
    threshold: '4'
    type: byte
  states: {}
- name: digital_costas_loop_cc_0
  id: digital_costas_loop_cc
  parameters:
    order: len(constel.points())
    w: 2*3.14/100
  states: {}
- name: digital_crc32_bb_0
  id: digital_crc32_bb
  parameters:
    check: 'False'
    lengthtagname: '"packet_len"'
    packed: 'True'
  states: {}
- name: digital_crc32_bb_1
  id: digital_crc32_bb
  parameters:
    check: 'True'
    lengthtagname: packet_len
    packed: 'True'
  states: {}
- name: digital_diff_decoder_bb_0
  id: digital_diff_decoder_bb
  parameters:
    coding: digital.DIFF_DIFFERENTIAL
    modulus: len(constel.points())
  states: {}
- name: digital_protocol_formatter_bb_0
  id: digital_protocol_formatter_bb
  parameters:
    format: hdr
    len_tag_key: packet_len
  states: {}
- name: digital_symbol_sync_xx_0
  id: digital_symbol_sync_xx
  parameters:
    constellation: constel.base()
    damping: '1.0'
    loop_bw: '0.045'
    max_dev: '1.5'
    nfilters: '32'
    osps: '1'
    resamp_type: digital.IR_MMSE_8TAP
    sps: sps
    ted_gain: '0.1'
    ted_type: digital.TED_SIGNAL_TIMES_SLOPE_ML
    type: cc
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr
      import pmt

      class blk(gr.sync_block):
          def __init__(self):
              gr.sync_block.__init__(self, name='Text to PDU', in_sig=None, out_sig=None)
              self.message_port_register_in(pmt.intern('msg_in'))
              self.message_port_register_out(pmt.intern('pdu_out'))
              self.set_msg_handler(pmt.intern('msg_in'), self.handle_msg)

          def handle_msg(self, msg):
              if pmt.is_pair(msg):
                  msg = pmt.cdr(msg)
              
              text = ""
              if pmt.is_symbol(msg):
                  text = pmt.symbol_to_string(msg)
              elif pmt.is_string(msg):
                  text = pmt.string_to_python(msg)
              else:
                  return

              text += '\n'
              
              # --- PACKET 1: The Real Message ---
              bytes_list = list(text.encode('utf-8'))
              if len(bytes_list) < 1024:
                  bytes_list.extend([32] * (1024 - len(bytes_list)))
              
              pdu_real = pmt.cons(pmt.make_dict(), pmt.init_u8vector(len(bytes_list), bytes_list))
              self.message_port_pub(pmt.intern('pdu_out'), pdu_real)
              
              # --- PACKET 2: The Dummy Flush Packet ---
              # Fires immediately after to push the real packet through the DSP filters.
              # The receiver's .strip() logic automatically ignores this packet.
              flush_list = [32] * 1024 
              pdu_flush = pmt.cons(pmt.make_dict(), pmt.init_u8vector(len(flush_list), flush_list))
              self.message_port_pub(pmt.intern('pdu_out'), pdu_flush)
  states: {state: disabled}
- name: epy_block_1
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr
      import pmt

      class blk(gr.sync_block):
          def __init__(self):
              gr.sync_block.__init__(self, name='PDU to Chat Log', in_sig=None, out_sig=None)
              self.message_port_register_in(pmt.intern('pdu_in'))
              self.message_port_register_out(pmt.intern('msg_out'))
              self.set_msg_handler(pmt.intern('pdu_in'), self.handle_msg)
              self.chat_history = []

          def handle_msg(self, msg):
              if pmt.is_pair(msg):
                  data = pmt.cdr(msg)
                  if pmt.is_u8vector(data):
                      bytes_data = bytes(pmt.u8vector_elements(data))
                      new_text = bytes_data.decode('utf-8', errors='ignore').strip()
                      
                      if new_text:
                          self.chat_history.append(f"Received: {new_text}")
                          if len(self.chat_history) > 10:
                              self.chat_history.pop(0)
                          
                          display_text = "\n".join(self.chat_history)
                          self.message_port_pub(pmt.intern('msg_out'), pmt.intern(display_text))
  states: {state: disabled}
- name: filter_fft_rrc_filter_0
  id: filter_fft_rrc_filter
  parameters:
    alpha: '0.35'
    decim: '1'
    gain: '1'
    ntaps: 11*sps
    samp_rate: samp_rate
    sym_rate: samp_rate/sps
    type: ccc
  states: {}
- name: iio_pluto_sink_0
  id: iio_pluto_sink
  parameters:
    attenuation1: '10.0'
    bandwidth: '20000000'
    buffer_size: '32768'
    cyclic: 'False'
    filter_source: '''Auto'''
    frequency: int(tx_freq)
    samplerate: int(samp_rate)
    type: fc32
    uri: '"ip:192.168.1.10"'
  states: {}
- name: iio_pluto_source_0
  id: iio_pluto_source
  parameters:
    bandwidth: '20000000'
    bbdc: 'True'
    buffer_size: '32768'
    filter_source: '''Auto'''
    frequency: int(rx_freq)
    gain1: '''slow_attack'''
    len_tag_key: ''
    quadrature: 'True'
    rfdc: 'True'
    samplerate: int(samp_rate)
    type: fc32
    uri: '"ip:192.168.1.10"'
  states: {}
- name: network_udp_sink_0
  id: network_udp_sink
  parameters:
    addr: 127.0.0.1
    header: '0'
    payloadsize: int(payload_size)
    port: '5002'
    send_eof: 'False'
    type: byte
  states: {}
- name: network_udp_source_0
  id: network_udp_source
  parameters:
    header: '0'
    ipv6: 'False'
    notify_missed: 'False'
    payloadsize: int(payload_size)
    port: '5001'
    src_zeros: 'False'
    type: byte
  states: {}
- name: note_0
  id: note
  parameters:
    note: Receiver
  states: {}
- name: note_1
  id: note
  parameters:
    note: transmitter
  states: {}
- name: note_2
  id: note
  parameters:
    note: Channel simulation
  states: {}
- name: pdu_pdu_to_tagged_stream_0
  id: pdu_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {state: disabled}
- name: pdu_tagged_stream_to_pdu_0
  id: pdu_tagged_stream_to_pdu
  parameters:
    tag: packet_len
    type: byte
  states: {state: disabled}
- name: qtgui_edit_box_msg_0
  id: qtgui_edit_box_msg
  parameters:
    is_pair: 'False'
    label: Transmission
    type: string
  states: {state: disabled}
- name: qtgui_edit_box_msg_0_0
  id: qtgui_edit_box_msg
  parameters:
    is_pair: 'False'
    is_static: 'False'
    label: Recieve
    type: string
  states: {state: disabled}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    grid: 'True'
    gui_hint: '[1, 0, 4, 3]'
    label1: Real
    label2: Imag
    name: Received Samples
    size: '1024'
    srate: samp_rate
    tr_delay: '0.0'
    tr_tag: ''
    type: complex
    ymax: '1.0'
    ymin: '-1.0'
  states: {state: disabled}
- name: qtgui_time_sink_x_1_0
  id: qtgui_time_sink_x
  parameters:
    grid: 'True'
    gui_hint: '[5, 0, 4, 3]'
    label1: Real
    label2: Imag
    name: Recovered Symbols
    size: '256'
    srate: samp_rate/sps
    style2: '3'
    tr_delay: '0.0'
    tr_level: '0.01'
    type: complex
    update_time: '0.1'
    ymax: '1.0'
    ymin: '-1.0'
  states: {state: disabled}
- name: snippet_0
  id: snippet
  parameters:
    code: |-
      with open("bpsk_transmit.txt", "w") as f:
              payload = "Hello World! \n \t - From WaveLink"
              f.write(payload)
    comment: Create transmit file
    section: init_before_blocks
  states: {state: disabled}
- name: snippet_1
  id: snippet
  parameters:
    code: |-
      import filecmp

      if filecmp.cmp("bpsk_transmit.txt", "bpsk_receive.txt", shallow=False):
          print("Successful file transfer")
      else:
         print("Error: Transmit and Receive files differ")
    comment: Compare transmit and receive file
    section: main_after_stop
  states: {state: disabled}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: tx_packet
  states: {}
- name: virtual_sink_0_0
  id: virtual_sink
  parameters:
    stream_id: header
  states: {}
- name: virtual_sink_2
  id: virtual_sink
  parameters:
    stream_id: channel
  states: {}
- name: virtual_sink_2_0
  id: virtual_sink
  parameters:
    stream_id: payload
  states: {}
- name: virtual_sink_3
  id: virtual_sink
  parameters:
    stream_id: recovery
  states: {}
- name: virtual_sink_4
  id: virtual_sink
  parameters:
    stream_id: rx_payload
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: tx_packet
  states: {}
- name: virtual_source_1
  id: virtual_source
  parameters:
    stream_id: channel
  states: {}
- name: virtual_source_2
  id: virtual_source
  parameters:
    stream_id: recovery
  states: {}
- name: virtual_source_3
  id: virtual_source
  parameters:
    stream_id: rx_payload
  states: {}
- name: virtual_source_5
  id: virtual_source
  parameters:
    stream_id: header
  states: {}
- name: virtual_source_6
  id: virtual_source
  parameters:
    stream_id: payload
  states: {}
- name: zeromq_pub_sink_0
  id: zeromq_pub_sink
  parameters:
    address: '"tcp://*:5555"'
    timeout: '100'
    type: complex
  states: {state: disabled}
- name: zeromq_sub_source_0
  id: zeromq_sub_source
  parameters:
    address: '"tcp://10.10.29.211:5555"'
    timeout: '100'
    type: complex
  states: {state: disabled}

connections:
- [blocks_file_source_0, '0', blocks_stream_to_tagged_stream_0_0_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_tag_gate_0, '0']
- [blocks_repack_bits_bb_1, '0', digital_crc32_bb_1, '0']
- [blocks_stream_to_tagged_stream_0, '0', digital_crc32_bb_0, '0']
- [blocks_stream_to_tagged_stream_0_0_0, '0', digital_crc32_bb_0, '0']
- [blocks_stream_to_tagged_stream_0_0_0_0, '0', blocks_tagged_stream_mux_0, '0']
- [blocks_stream_to_tagged_stream_0_0_0_0_0, '0', blocks_tagged_stream_mux_0, '3']
- [blocks_tag_gate_0, '0', blocks_throttle2_0, '0']
- [blocks_tag_gate_0, '0', iio_pluto_sink_0, '0']
- [blocks_tagged_stream_mux_0, '0', virtual_sink_0, '0']
- [blocks_throttle2_0, '0', zeromq_pub_sink_0, '0']
- [blocks_vector_source_x_0, '0', blocks_stream_to_tagged_stream_0_0_0_0, '0']
- [blocks_vector_source_x_0_0, '0', blocks_stream_to_tagged_stream_0_0_0_0_0, '0']
- [digital_constellation_decoder_cb_1, '0', digital_diff_decoder_bb_0, '0']
- [digital_constellation_modulator_0, '0', blocks_multiply_const_vxx_0, '0']
- [digital_correlate_access_code_xx_ts_0, '0', virtual_sink_4, '0']
- [digital_costas_loop_cc_0, '0', qtgui_time_sink_x_1_0, '0']
- [digital_costas_loop_cc_0, '0', virtual_sink_3, '0']
- [digital_crc32_bb_0, '0', digital_protocol_formatter_bb_0, '0']
- [digital_crc32_bb_0, '0', virtual_sink_2_0, '0']
- [digital_crc32_bb_1, '0', blocks_file_sink_0, '0']
- [digital_crc32_bb_1, '0', network_udp_sink_0, '0']
- [digital_crc32_bb_1, '0', pdu_tagged_stream_to_pdu_0, '0']
- [digital_diff_decoder_bb_0, '0', digital_correlate_access_code_xx_ts_0, '0']
- [digital_protocol_formatter_bb_0, '0', virtual_sink_0_0, '0']
- [digital_symbol_sync_xx_0, '0', digital_costas_loop_cc_0, '0']
- [epy_block_0, pdu_out, pdu_pdu_to_tagged_stream_0, pdus]
- [epy_block_1, msg_out, qtgui_edit_box_msg_0_0, val]
- [filter_fft_rrc_filter_0, '0', digital_symbol_sync_xx_0, '0']
- [iio_pluto_source_0, '0', qtgui_time_sink_x_0_0, '0']
- [iio_pluto_source_0, '0', virtual_sink_2, '0']
- [network_udp_source_0, '0', blocks_stream_to_tagged_stream_0, '0']
- [pdu_pdu_to_tagged_stream_0, '0', digital_crc32_bb_0, '0']
- [pdu_tagged_stream_to_pdu_0, pdus, blocks_message_debug_0, print]
- [pdu_tagged_stream_to_pdu_0, pdus, epy_block_1, pdu_in]
- [qtgui_edit_box_msg_0, msg, epy_block_0, msg_in]
- [virtual_source_0, '0', digital_constellation_modulator_0, '0']
- [virtual_source_1, '0', filter_fft_rrc_filter_0, '0']
- [virtual_source_2, '0', digital_constellation_decoder_cb_1, '0']
- [virtual_source_3, '0', blocks_repack_bits_bb_1, '0']
- [virtual_source_5, '0', blocks_tagged_stream_mux_0, '1']
- [virtual_source_6, '0', blocks_tagged_stream_mux_0, '2']
- [zeromq_sub_source_0, '0', qtgui_time_sink_x_0_0, '0']
- [zeromq_sub_source_0, '0', virtual_sink_2, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
