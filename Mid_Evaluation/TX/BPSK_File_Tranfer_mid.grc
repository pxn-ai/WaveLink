options:
  parameters:
    author: Team WaveLink
    generate_options: qt_gui
    id: BPSK_File_Transfer
    output_language: python
    title: Plut_SDR_File_TX
  states: {}

blocks:
- name: constel
  id: variable_constellation
  parameters:
    precision: '8'
    type: bpsk
  states: {}
- name: frequency
  id: variable
  parameters:
    value: 905.2e6
  states: {}
- name: hdr
  id: variable
  parameters:
    value: digital.header_format_default(digital.packet_utils.default_access_code, 0)
  states: {}
- name: payload_size
  id: variable
  parameters:
    value: '1024'
  states: {}
- name: postamble_size
  id: variable
  parameters:
    value: '10000'
  states: {}
- name: preamble_size
  id: variable
  parameters:
    value: '384'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '2000000'
  states: {}
- name: sps
  id: variable
  parameters:
    value: '4'
  states: {}
- name: tx_atten
  id: variable_qtgui_range
  parameters:
    comment: 'NOTE: attenuation!'
    label: Tx Attenuation
    start: '0'
    step: '1'
    stop: '30'
    value: '10'
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/pxn-ai/Downloads/color_test_800x600_118kb.jpg
    repeat: 'False'
    type: byte
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '0.5'
    type: complex
  states: {}
- name: blocks_stream_to_tagged_stream_0_0_0
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: '"packet_len"'
    packet_len: payload_size
    type: byte
  states: {}
- name: blocks_stream_to_tagged_stream_0_0_0_0
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: '"packet_len"'
    packet_len: preamble_size
    type: byte
  states: {}
- name: blocks_tagged_stream_mux_0
  id: blocks_tagged_stream_mux
  parameters:
    lengthtagname: packet_len
    ninputs: '3'
    type: byte
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {state: disabled}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    comment: Preamble
    repeat: 'True'
    type: byte
    vector: '[0xc0, 0xaf]'
  states: {}
- name: digital_constellation_modulator_0
  id: digital_constellation_modulator
  parameters:
    constellation: constel
    differential: 'True'
    excess_bw: '0.35'
    samples_per_symbol: sps
  states: {}
- name: digital_crc32_bb_0
  id: digital_crc32_bb
  parameters:
    check: 'False'
    lengthtagname: '"packet_len"'
    packed: 'True'
  states: {}
- name: digital_protocol_formatter_bb_0
  id: digital_protocol_formatter_bb
  parameters:
    format: hdr
    len_tag_key: packet_len
  states: {}
- name: iio_pluto_sink_0
  id: iio_pluto_sink
  parameters:
    attenuation1: tx_atten
    bandwidth: samp_rate
    buffer_size: '32768'
    cyclic: 'False'
    filter_source: '''Auto'''
    frequency: int(frequency)
    samplerate: int(samp_rate)
    type: fc32
    uri: '"ip:192.168.1.10"'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    name: '"Transmit data"'
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: snippet_0
  id: snippet
  parameters:
    code: |-
      with open("bpsk_transmit.txt", "w") as f:
      	payload = "Hello World! \n \t - from WaveLink"
      	f.write(payload)
    comment: Create transmit file
    section: init_before_blocks
  states: {}
- name: virtual_sink_0_0
  id: virtual_sink
  parameters:
    stream_id: header
  states: {}
- name: virtual_sink_2_0
  id: virtual_sink
  parameters:
    stream_id: payload
  states: {}
- name: virtual_source_5
  id: virtual_source
  parameters:
    stream_id: header
  states: {}
- name: virtual_source_6
  id: virtual_source
  parameters:
    stream_id: payload
  states: {}
- name: zeromq_pub_sink_0
  id: zeromq_pub_sink
  parameters:
    address: '"tcp://*:5555"'
    timeout: '100'
    type: complex
  states: {state: disabled}

connections:
- [blocks_file_source_0, '0', blocks_stream_to_tagged_stream_0_0_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_throttle2_0, '0']
- [blocks_multiply_const_vxx_0, '0', iio_pluto_sink_0, '0']
- [blocks_multiply_const_vxx_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_stream_to_tagged_stream_0_0_0, '0', digital_crc32_bb_0, '0']
- [blocks_stream_to_tagged_stream_0_0_0_0, '0', blocks_tagged_stream_mux_0, '0']
- [blocks_tagged_stream_mux_0, '0', digital_constellation_modulator_0, '0']
- [blocks_throttle2_0, '0', zeromq_pub_sink_0, '0']
- [blocks_vector_source_x_0, '0', blocks_stream_to_tagged_stream_0_0_0_0, '0']
- [digital_constellation_modulator_0, '0', blocks_multiply_const_vxx_0, '0']
- [digital_crc32_bb_0, '0', digital_protocol_formatter_bb_0, '0']
- [digital_crc32_bb_0, '0', virtual_sink_2_0, '0']
- [digital_protocol_formatter_bb_0, '0', virtual_sink_0_0, '0']
- [virtual_source_5, '0', blocks_tagged_stream_mux_0, '1']
- [virtual_source_6, '0', blocks_tagged_stream_mux_0, '2']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
