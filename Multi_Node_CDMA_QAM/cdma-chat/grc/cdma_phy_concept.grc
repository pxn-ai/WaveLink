options:
  parameters:
    author: EN2130 group
    description: Two-user DS-CDMA with stock blocks
    generate_options: qt_gui
    id: cdma_phy_concept
    output_language: python
    title: 'EN2130 DS-CDMA concept: spreading and despreading'
  states: {}

blocks:
- name: code1
  id: variable
  parameters:
    value: '[-1, -1, -1, -1, -1, 1, 1, -1, 1, 1, -1, -1, 1, 1, 1, 1, -1, 1, -1, -1, 1, -1, 1, -1, 1, 1, 1, -1, -1, -1, 1]'
  states: {}
- name: code2
  id: variable
  parameters:
    value: '[-1, -1, 1, -1, -1, -1, -1, -1, -1, 1, -1, -1, 1, 1, -1, 1, -1, 1, 1, 1, -1, 1, 1, 1, 1, 1, 1, 1, -1, -1, -1]'
  states: {}
- name: code3
  id: variable
  parameters:
    value: '[-1, 1, -1, -1, 1, -1, 1, -1, -1, 1, 1, 1, -1, 1, 1, -1, 1, -1, -1, 1, -1, -1, 1, 1, -1, -1, 1, 1, -1, -1, 1]'
  states: {}
- name: noise_amp
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,0,1,2
    label: Noise amplitude
    start: '0'
    step: '0.1'
    stop: '5'
    value: '1.0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    comment: 1 sample per chip
    value: 1e6
  states: {}
- name: sf
  id: variable
  parameters:
    value: '31'
  states: {}
- name: user2_gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,0,1,2
    label: User 2 amplitude (near-far)
    start: '0'
    step: '0.1'
    stop: '5'
    value: '1.0'
  states: {}
- name: air
  id: blocks_add_xx
  parameters:
    num_inputs: '3'
    type: complex
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: chips_scope
  id: qtgui_time_sink_x
  parameters:
    entags: 'False'
    gui_hint: 5,0,1,2
    label1: '''I'''
    label2: '''Q'''
    name: '"Chips on air (noise-like)"'
    size: '310'
    srate: samp_rate
    type: complex
    update_time: '0.2'
    ymax: '4'
    ymin: '-4'
  states: {}
- name: const
  id: qtgui_const_sink_x
  parameters:
    grid: 'True'
    gui_hint: 3,0,2,2
    label1: '''despread with code 1 (user 1)'''
    label2: '''despread with code 2 (user 2)'''
    label3: '''despread with code 3 (nobody)'''
    name: '"Despread symbols: right code vs wrong code"'
    nconnections: '3'
    size: '512'
    type: complex
    xmax: '2.5'
    xmin: '-2.5'
    ymax: '2.5'
    ymin: '-2.5'
  states: {}
- name: d1_code
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: complex
    vector: code1
  states: {}
- name: d1_dump
  id: blocks_integrate_xx
  parameters:
    decim: sf
    type: complex
  states: {}
- name: d1_mix
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: d1_norm
  id: blocks_multiply_const_vxx
  parameters:
    const: 1/sf
    type: complex
  states: {}
- name: d2_code
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: complex
    vector: code2
  states: {}
- name: d2_dump
  id: blocks_integrate_xx
  parameters:
    decim: sf
    type: complex
  states: {}
- name: d2_mix
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: d2_norm
  id: blocks_multiply_const_vxx
  parameters:
    const: 1/sf
    type: complex
  states: {}
- name: d3_code
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: complex
    vector: code3
  states: {}
- name: d3_dump
  id: blocks_integrate_xx
  parameters:
    decim: sf
    type: complex
  states: {}
- name: d3_mix
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: d3_norm
  id: blocks_multiply_const_vxx
  parameters:
    const: 1/sf
    type: complex
  states: {}
- name: noise_src
  id: analog_noise_source_x
  parameters:
    amp: noise_amp
    noise_type: analog.GR_GAUSSIAN
    seed: '42'
    type: complex
  states: {}
- name: note_about
  id: note
  parameters:
    note: DS-CDMA from stock GNU Radio blocks. Two users send random BPSK bits, each spread by its own 31-chip Gold code (the same codes the chat system gives node 1 and node 2). The sum plus noise is despread with code 1, code 2, and an unused code 3. Despreading with the right code recovers +/-1; the wrong code gives only noise. Compare the narrow BPSK spectrum with the 31x wider spread spectrum. (Rectangular chips, perfect sync, for teaching.)
  states: {}
- name: spec
  id: qtgui_freq_sink_x
  parameters:
    average: '0.2'
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    grid: 'True'
    gui_hint: 2,0,1,2
    label1: '''BPSK before spreading'''
    label2: '''On air (2 users + noise)'''
    name: '"Narrowband BPSK (user 1) vs spread signal on air"'
    nconnections: '2'
    type: complex
    ymax: '-10'
    ymin: '-120'
  states: {}
- name: u1_bits
  id: analog_random_source_x
  parameters:
    max: '2'
    min: '0'
    num_samps: '10000'
    repeat: 'True'
    type: byte
  states: {}
- name: u1_bpsk
  id: digital_chunks_to_symbols_xx
  parameters:
    dimension: '1'
    in_type: byte
    out_type: complex
    symbol_table: '[-1, 1]'
  states: {}
- name: u1_code
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: complex
    vector: code1
  states: {}
- name: u1_repeat
  id: blocks_repeat
  parameters:
    interp: sf
    type: complex
  states: {}
- name: u1_spread
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: u2_bits
  id: analog_random_source_x
  parameters:
    max: '2'
    min: '0'
    num_samps: '10000'
    repeat: 'True'
    type: byte
  states: {}
- name: u2_bpsk
  id: digital_chunks_to_symbols_xx
  parameters:
    dimension: '1'
    in_type: byte
    out_type: complex
    symbol_table: '[-1, 1]'
  states: {}
- name: u2_code
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: complex
    vector: code2
  states: {}
- name: u2_level
  id: blocks_multiply_const_vxx
  parameters:
    const: user2_gain
    type: complex
  states: {}
- name: u2_repeat
  id: blocks_repeat
  parameters:
    interp: sf
    type: complex
  states: {}
- name: u2_spread
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}

connections:
- [air, '0', blocks_throttle2_0, '0']
- [blocks_throttle2_0, '0', chips_scope, '0']
- [blocks_throttle2_0, '0', d1_mix, '0']
- [blocks_throttle2_0, '0', d2_mix, '0']
- [blocks_throttle2_0, '0', d3_mix, '0']
- [blocks_throttle2_0, '0', spec, '1']
- [d1_code, '0', d1_mix, '1']
- [d1_dump, '0', d1_norm, '0']
- [d1_mix, '0', d1_dump, '0']
- [d1_norm, '0', const, '0']
- [d2_code, '0', d2_mix, '1']
- [d2_dump, '0', d2_norm, '0']
- [d2_mix, '0', d2_dump, '0']
- [d2_norm, '0', const, '1']
- [d3_code, '0', d3_mix, '1']
- [d3_dump, '0', d3_norm, '0']
- [d3_mix, '0', d3_dump, '0']
- [d3_norm, '0', const, '2']
- [noise_src, '0', air, '2']
- [u1_bits, '0', u1_bpsk, '0']
- [u1_bpsk, '0', u1_repeat, '0']
- [u1_code, '0', u1_spread, '1']
- [u1_repeat, '0', spec, '0']
- [u1_repeat, '0', u1_spread, '0']
- [u1_spread, '0', air, '0']
- [u2_bits, '0', u2_bpsk, '0']
- [u2_bpsk, '0', u2_repeat, '0']
- [u2_code, '0', u2_spread, '1']
- [u2_level, '0', air, '1']
- [u2_repeat, '0', u2_spread, '0']
- [u2_spread, '0', u2_level, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
