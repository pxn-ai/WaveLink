options:
  parameters:
    author: EN2130 group
    description: One station of the multi-node DS-CDMA chat system
    generate_options: qt_gui
    id: cdma_station
    output_language: python
    title: EN2130 DS-CDMA Chat Station (ANTSDR E200, libiio)
  states: {}

blocks:
- name: note_about
  id: note
  parameters:
    note: 'DS-CDMA chat station on an ANTSDR E200 (Pluto/libiio firmware, boot switch = QSPI). Payload BPSK/QPSK/16-QAM adapts per link (fast profile: up to 258 kb/s). Run, then open http://localhost:<web_port>. All stations must share samp_rate and center_freq; each needs a different node_id. Command line: python3 cdma_station.py -i 2 -n Bob'
  states: {}
- name: node_id
  id: parameter
  parameters:
    label: 'Node ID (= Gold code #)'
    type: intx
    value: '1'
    short_id: i
  states: {}
- name: station_name
  id: parameter
  parameters:
    label: Station name
    type: str
    value: Alice
    short_id: n
  states: {}
- name: web_port
  id: parameter
  parameters:
    label: Web UI port
    type: intx
    value: '8080'
    short_id: p
  states: {}
- name: enc_key
  id: parameter
  parameters:
    label: Encryption passphrase ('' = off)
    type: str
    value: ''
    short_id: k
  states: {}
- name: profile
  id: parameter
  parameters:
    label: 'Speed profile: fast | robust'
    type: str
    value: fast
  states: {}
- name: mod_policy
  id: parameter
  parameters:
    label: 'Modulation: auto | bpsk | qpsk | 16qam'
    type: str
    value: auto
    short_id: m
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 4e6
  states: {}
- name: center_freq
  id: variable
  parameters:
    value: 2.5e9
  states: {}
- name: tx_buffer
  id: variable
  parameters:
    value: '131072'
    comment: |-
      TX driver buffer (33 ms).
      Larger = no mid-burst underruns.
  states: {}
- name: uri
  id: parameter
  parameters:
    label: ANTSDR URI
    type: str
    value: ip:192.168.1.10
    short_id: u
  states: {}
- name: rx_gain
  id: variable_qtgui_range
  parameters:
    label: RX gain (dB)
    value: '40'
    start: '0'
    stop: '71'
    step: '1'
    gui_hint: 0,0,1,1
  states: {}
- name: tx_atten
  id: variable_qtgui_range
  parameters:
    label: TX attenuation (dB, 0 = max power)
    value: '10'
    start: '0'
    stop: '89'
    step: '1'
    gui_hint: 0,1,1,1
  states: {}
- name: antsdr_rx
  id: iio_fmcomms2_source
  parameters:
    type: fc32
    uri: uri
    frequency: int(center_freq)
    samplerate: int(samp_rate)
    bandwidth: int(samp_rate)
    buffer_size: '32768'
    rx1_en: 'True'
    rx2_en: 'False'
    gain1: '''manual'''
    manual_gain1: rx_gain
    quadrature: 'True'
    rfdc: 'True'
    bbdc: 'True'
    len_tag_key: ''''''
    filter_source: '''Auto'''
  states: {}
- name: cdma_rx
  id: epy_block
  parameters:
    _source_code: |
      """
      CDMA Chat RX - receive side of a DS-CDMA station.

      Feeds the received baseband samples to the station's demodulator, which
      runs in its own thread: RRC matched filter, Gold-code correlators for this
      node's code and the broadcast code, CFO-immune differential preamble
      detector, PLL + DLL despreading, CRC-8 header check, then the link layer
      (CRC-32, addressing, ACKs).  Several same-code bursts that overlap in time
      are decoded independently.

      Connect the ANTSDR source to its input.  Use the same node_id as the
      'CDMA Chat TX' block of this station.
      """
      import os
      import sys
      import numpy as np
      from gnuradio import gr

      # Make the cdmachat package importable: this file is generated next to the .grc,
      # and the .grc lives in <project>/grc/.
      _HERE = os.path.dirname(os.path.abspath(globals().get("__file__", os.getcwd() + "/x")))
      for _cand in (os.path.join(_HERE, ".."), _HERE, os.getcwd(), os.path.join(os.getcwd(), "..")):
          if os.path.isdir(os.path.join(_cand, "cdmachat")):
              sys.path.insert(0, os.path.abspath(_cand))
              break


      class blk(gr.sync_block):
          def __init__(self, node_id=1, station_name="Alice", web_port=8080, enc_key="",
                       samp_rate=4e6, center_freq=2.5e9, tx_buffer=131072, profile="fast",
                       mod_policy="auto", mode="antsdr"):
              gr.sync_block.__init__(self, name="CDMA Chat RX", in_sig=[np.complex64], out_sig=None)
              self.args = (int(node_id), station_name, int(web_port), enc_key, float(samp_rate),
                           float(center_freq), int(tx_buffer))
              self.kw = dict(profile=profile, mod_policy=mod_policy)
              self.mode = mode
              self.station = None

          def start(self):
              from cdmachat.grc_glue import get_station
              self.station = get_station(*self.args, mode=self.mode, **self.kw)
              self.station.start()
              return True

          def stop(self):
              if self.station is not None:
                  self.station.stop()
                  self.station = None
              return True

          def work(self, input_items, output_items):
              if self.station is not None:
                  self.station.radio.rx_push(input_items[0])
              return len(input_items[0])
    node_id: node_id
    station_name: station_name
    web_port: web_port
    enc_key: enc_key
    samp_rate: samp_rate
    center_freq: center_freq
    tx_buffer: tx_buffer
    profile: profile
    mod_policy: mod_policy
    mode: '''antsdr'''
  states: {}
- name: rx_spectrum
  id: qtgui_freq_sink_x
  parameters:
    type: complex
    name: '"Received spectrum (2.5 GHz)"'
    fftsize: '1024'
    fc: center_freq
    bw: samp_rate
    ymin: '-120'
    ymax: '-10'
    average: '0.2'
    gui_hint: 1,0,1,2
    grid: 'True'
    label1: ''''''
  states: {}
- name: rx_waterfall
  id: qtgui_waterfall_sink_x
  parameters:
    type: complex
    name: '"Received waterfall: CDMA bursts"'
    fftsize: '512'
    fc: center_freq
    bw: samp_rate
    int_min: '-110'
    int_max: '-30'
    gui_hint: 2,0,1,2
  states: {}
- name: cdma_tx
  id: epy_block
  parameters:
    _source_code: |
      """
      CDMA Chat TX - one DS-CDMA station (transmit side + the whole station).

      When the flowgraph starts this block starts the station: link layer
      (addressing, CRC-32, fragmentation, selective-repeat ARQ, priority),
      chat application and the web UI on http://localhost:<web_port>.
      Its output is the station's transmit signal: zeros when idle, and
      DS-CDMA bursts (31-chip Gold codes, RRC pulses; BPSK preamble/header,
      BPSK / QPSK / 16-QAM payload chosen per link) whenever the link layer sends. Bursts for different stations are spread with different
      codes and summed, so several links share 2.5 GHz at the same time.

      Connect the output to the ANTSDR sink.  Pair it with a 'CDMA Chat RX'
      block that has the same node_id.
      """
      import os
      import sys
      import numpy as np
      from gnuradio import gr

      # Make the cdmachat package importable: this file is generated next to the .grc,
      # and the .grc lives in <project>/grc/.
      _HERE = os.path.dirname(os.path.abspath(globals().get("__file__", os.getcwd() + "/x")))
      for _cand in (os.path.join(_HERE, ".."), _HERE, os.getcwd(), os.path.join(os.getcwd(), "..")):
          if os.path.isdir(os.path.join(_cand, "cdmachat")):
              sys.path.insert(0, os.path.abspath(_cand))
              break


      class blk(gr.sync_block):
          def __init__(self, node_id=1, station_name="Alice", web_port=8080, enc_key="",
                       samp_rate=4e6, center_freq=2.5e9, tx_buffer=131072, profile="fast",
                       mod_policy="auto", mode="antsdr"):
              gr.sync_block.__init__(self, name="CDMA Chat TX", in_sig=None, out_sig=[np.complex64])
              self.node_id = int(node_id)
              self.station_name = station_name
              self.web_port = int(web_port)
              self.enc_key = enc_key
              self.samp_rate = float(samp_rate)
              self.center_freq = float(center_freq)
              self.tx_buffer = int(tx_buffer)
              self.profile = profile
              self.mod_policy = mod_policy
              self.mode = mode
              self.station = None

          def start(self):
              from cdmachat.grc_glue import get_station
              self.station = get_station(self.node_id, self.station_name, self.web_port, self.enc_key,
                                         self.samp_rate, self.center_freq, self.tx_buffer,
                                         profile=self.profile, mod_policy=self.mod_policy, mode=self.mode)
              self.station.start()
              return True

          def stop(self):
              if self.station is not None:
                  self.station.stop()
                  self.station = None
              return True

          def work(self, input_items, output_items):
              out = output_items[0]
              if self.station is None:
                  out[:] = 0
              else:
                  out[:] = self.station.radio.tx_read(len(out))
              return len(out)
    node_id: node_id
    station_name: station_name
    web_port: web_port
    enc_key: enc_key
    samp_rate: samp_rate
    center_freq: center_freq
    tx_buffer: tx_buffer
    profile: profile
    mod_policy: mod_policy
    mode: '''antsdr'''
  states: {}
- name: antsdr_tx
  id: iio_fmcomms2_sink
  parameters:
    type: fc32
    uri: uri
    frequency: int(center_freq)
    samplerate: int(samp_rate)
    bandwidth: int(samp_rate)
    buffer_size: tx_buffer
    tx1_en: 'True'
    tx2_en: 'False'
    cyclic: 'False'
    attenuation1: tx_atten
    len_tag_key: ''''''
    filter_source: '''Auto'''
  states: {}
- name: tx_scope
  id: qtgui_time_sink_x
  parameters:
    type: complex
    name: '"Transmitted baseband (bursts)"'
    size: '40000'
    srate: samp_rate
    update_time: '0.2'
    gui_hint: 3,0,1,2
    label1: '''I'''
    label2: '''Q'''
    entags: 'False'
  states: {}

connections:
- [antsdr_rx, '0', cdma_rx, '0']
- [antsdr_rx, '0', rx_spectrum, '0']
- [antsdr_rx, '0', rx_waterfall, '0']
- [cdma_tx, '0', antsdr_tx, '0']
- [cdma_tx, '0', tx_scope, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
