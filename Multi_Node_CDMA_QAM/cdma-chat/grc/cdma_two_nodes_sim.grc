options:
  parameters:
    author: EN2130 group
    description: Two full stations over a simulated channel (no hardware)
    generate_options: qt_gui
    id: cdma_two_nodes_sim
    output_language: python
    title: EN2130 DS-CDMA Chat - two stations, simulated channel
  states: {}

blocks:
- name: note_about
  id: note
  parameters:
    note: 'No hardware needed: two complete stations share one simulated 2.5 GHz channel. Open http://localhost:8081 (Alice) and http://localhost:8082 (Bob). Move the noise slider: the link adapts 16-QAM -> QPSK -> BPSK and you see CRC drops and ARQ retransmissions in the web dashboard.'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2e6
    comment: |-
      2 MS/s: two receivers run in this one process,
      so use half the rate of the hardware graph.
  states: {}
- name: center_freq
  id: variable
  parameters:
    value: 2.5e9
  states: {}
- name: tx_buffer
  id: variable
  parameters:
    value: '131072'
    comment: |-
      TX driver buffer (33 ms).
      Larger = no mid-burst underruns.
  states: {}
- name: noise
  id: variable_qtgui_range
  parameters:
    label: Channel noise voltage
    value: '0.01'
    start: '0'
    stop: '0.6'
    step: '0.005'
    gui_hint: 0,0,1,2
  states: {}
- name: cfo_hz
  id: variable_qtgui_range
  parameters:
    label: Carrier offset between radios (Hz)
    value: '3000'
    start: '-15000'
    stop: '15000'
    step: '500'
    gui_hint: 1,0,1,2
  states: {}
- name: alice_tx
  id: epy_block
  parameters:
    _source_code: |
      """
      CDMA Chat TX - one DS-CDMA station (transmit side + the whole station).

      When the flowgraph starts this block starts the station: link layer
      (addressing, CRC-32, fragmentation, selective-repeat ARQ, priority),
      chat application and the web UI on http://localhost:<web_port>.
      Its output is the station's transmit signal: zeros when idle, and
      DS-CDMA bursts (31-chip Gold codes, RRC pulses; BPSK preamble/header,
      BPSK / QPSK / 16-QAM payload chosen per link) whenever the link layer sends. Bursts for different stations are spread with different
      codes and summed, so several links share 2.5 GHz at the same time.

      Connect the output to the ANTSDR sink.  Pair it with a 'CDMA Chat RX'
      block that has the same node_id.
      """
      import os
      import sys
      import numpy as np
      from gnuradio import gr

      # Make the cdmachat package importable: this file is generated next to the .grc,
      # and the .grc lives in <project>/grc/.
      _HERE = os.path.dirname(os.path.abspath(globals().get("__file__", os.getcwd() + "/x")))
      for _cand in (os.path.join(_HERE, ".."), _HERE, os.getcwd(), os.path.join(os.getcwd(), "..")):
          if os.path.isdir(os.path.join(_cand, "cdmachat")):
              sys.path.insert(0, os.path.abspath(_cand))
              break


      class blk(gr.sync_block):
          def __init__(self, node_id=1, station_name="Alice", web_port=8080, enc_key="",
                       samp_rate=4e6, center_freq=2.5e9, tx_buffer=131072, profile="fast",
                       mod_policy="auto", mode="antsdr"):
              gr.sync_block.__init__(self, name="CDMA Chat TX", in_sig=None, out_sig=[np.complex64])
              self.node_id = int(node_id)
              self.station_name = station_name
              self.web_port = int(web_port)
              self.enc_key = enc_key
              self.samp_rate = float(samp_rate)
              self.center_freq = float(center_freq)
              self.tx_buffer = int(tx_buffer)
              self.profile = profile
              self.mod_policy = mod_policy
              self.mode = mode
              self.station = None

          def start(self):
              from cdmachat.grc_glue import get_station
              self.station = get_station(self.node_id, self.station_name, self.web_port, self.enc_key,
                                         self.samp_rate, self.center_freq, self.tx_buffer,
                                         profile=self.profile, mod_policy=self.mod_policy, mode=self.mode)
              self.station.start()
              return True

          def stop(self):
              if self.station is not None:
                  self.station.stop()
                  self.station = None
              return True

          def work(self, input_items, output_items):
              out = output_items[0]
              if self.station is None:
                  out[:] = 0
              else:
                  out[:] = self.station.radio.tx_read(len(out))
              return len(out)
    node_id: '1'
    station_name: '''Alice'''
    web_port: '8081'
    enc_key: ''''''
    samp_rate: samp_rate
    center_freq: center_freq
    tx_buffer: tx_buffer
    profile: '''fast'''
    mod_policy: '''auto'''
    mode: '''grc-sim'''
  states: {}
- name: bob_tx
  id: epy_block
  parameters:
    _source_code: |
      """
      CDMA Chat TX - one DS-CDMA station (transmit side + the whole station).

      When the flowgraph starts this block starts the station: link layer
      (addressing, CRC-32, fragmentation, selective-repeat ARQ, priority),
      chat application and the web UI on http://localhost:<web_port>.
      Its output is the station's transmit signal: zeros when idle, and
      DS-CDMA bursts (31-chip Gold codes, RRC pulses; BPSK preamble/header,
      BPSK / QPSK / 16-QAM payload chosen per link) whenever the link layer sends. Bursts for different stations are spread with different
      codes and summed, so several links share 2.5 GHz at the same time.

      Connect the output to the ANTSDR sink.  Pair it with a 'CDMA Chat RX'
      block that has the same node_id.
      """
      import os
      import sys
      import numpy as np
      from gnuradio import gr

      # Make the cdmachat package importable: this file is generated next to the .grc,
      # and the .grc lives in <project>/grc/.
      _HERE = os.path.dirname(os.path.abspath(globals().get("__file__", os.getcwd() + "/x")))
      for _cand in (os.path.join(_HERE, ".."), _HERE, os.getcwd(), os.path.join(os.getcwd(), "..")):
          if os.path.isdir(os.path.join(_cand, "cdmachat")):
              sys.path.insert(0, os.path.abspath(_cand))
              break


      class blk(gr.sync_block):
          def __init__(self, node_id=1, station_name="Alice", web_port=8080, enc_key="",
                       samp_rate=4e6, center_freq=2.5e9, tx_buffer=131072, profile="fast",
                       mod_policy="auto", mode="antsdr"):
              gr.sync_block.__init__(self, name="CDMA Chat TX", in_sig=None, out_sig=[np.complex64])
              self.node_id = int(node_id)
              self.station_name = station_name
              self.web_port = int(web_port)
              self.enc_key = enc_key
              self.samp_rate = float(samp_rate)
              self.center_freq = float(center_freq)
              self.tx_buffer = int(tx_buffer)
              self.profile = profile
              self.mod_policy = mod_policy
              self.mode = mode
              self.station = None

          def start(self):
              from cdmachat.grc_glue import get_station
              self.station = get_station(self.node_id, self.station_name, self.web_port, self.enc_key,
                                         self.samp_rate, self.center_freq, self.tx_buffer,
                                         profile=self.profile, mod_policy=self.mod_policy, mode=self.mode)
              self.station.start()
              return True

          def stop(self):
              if self.station is not None:
                  self.station.stop()
                  self.station = None
              return True

          def work(self, input_items, output_items):
              out = output_items[0]
              if self.station is None:
                  out[:] = 0
              else:
                  out[:] = self.station.radio.tx_read(len(out))
              return len(out)
    node_id: '2'
    station_name: '''Bob'''
    web_port: '8082'
    enc_key: ''''''
    samp_rate: samp_rate
    center_freq: center_freq
    tx_buffer: tx_buffer
    profile: '''fast'''
    mod_policy: '''auto'''
    mode: '''grc-sim'''
  states: {}
- name: air_sum
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: throttle
  id: blocks_throttle
  parameters:
    type: complex
    samples_per_second: samp_rate
  states: {}
- name: channel
  id: channels_channel_model
  parameters:
    noise_voltage: noise
    freq_offset: cfo_hz/samp_rate
    epsilon: '1.0'
    taps: '[1.0+0j]'
    seed: '0'
  states: {}
- name: alice_rx
  id: epy_block
  parameters:
    _source_code: |
      """
      CDMA Chat RX - receive side of a DS-CDMA station.

      Feeds the received baseband samples to the station's demodulator, which
      runs in its own thread: RRC matched filter, Gold-code correlators for this
      node's code and the broadcast code, CFO-immune differential preamble
      detector, PLL + DLL despreading, CRC-8 header check, then the link layer
      (CRC-32, addressing, ACKs).  Several same-code bursts that overlap in time
      are decoded independently.

      Connect the ANTSDR source to its input.  Use the same node_id as the
      'CDMA Chat TX' block of this station.
      """
      import os
      import sys
      import numpy as np
      from gnuradio import gr

      # Make the cdmachat package importable: this file is generated next to the .grc,
      # and the .grc lives in <project>/grc/.
      _HERE = os.path.dirname(os.path.abspath(globals().get("__file__", os.getcwd() + "/x")))
      for _cand in (os.path.join(_HERE, ".."), _HERE, os.getcwd(), os.path.join(os.getcwd(), "..")):
          if os.path.isdir(os.path.join(_cand, "cdmachat")):
              sys.path.insert(0, os.path.abspath(_cand))
              break


      class blk(gr.sync_block):
          def __init__(self, node_id=1, station_name="Alice", web_port=8080, enc_key="",
                       samp_rate=4e6, center_freq=2.5e9, tx_buffer=131072, profile="fast",
                       mod_policy="auto", mode="antsdr"):
              gr.sync_block.__init__(self, name="CDMA Chat RX", in_sig=[np.complex64], out_sig=None)
              self.args = (int(node_id), station_name, int(web_port), enc_key, float(samp_rate),
                           float(center_freq), int(tx_buffer))
              self.kw = dict(profile=profile, mod_policy=mod_policy)
              self.mode = mode
              self.station = None

          def start(self):
              from cdmachat.grc_glue import get_station
              self.station = get_station(*self.args, mode=self.mode, **self.kw)
              self.station.start()
              return True

          def stop(self):
              if self.station is not None:
                  self.station.stop()
                  self.station = None
              return True

          def work(self, input_items, output_items):
              if self.station is not None:
                  self.station.radio.rx_push(input_items[0])
              return len(input_items[0])
    node_id: '1'
    station_name: '''Alice'''
    web_port: '8081'
    enc_key: ''''''
    samp_rate: samp_rate
    center_freq: center_freq
    tx_buffer: tx_buffer
    profile: '''fast'''
    mod_policy: '''auto'''
    mode: '''grc-sim'''
  states: {}
- name: bob_rx
  id: epy_block
  parameters:
    _source_code: |
      """
      CDMA Chat RX - receive side of a DS-CDMA station.

      Feeds the received baseband samples to the station's demodulator, which
      runs in its own thread: RRC matched filter, Gold-code correlators for this
      node's code and the broadcast code, CFO-immune differential preamble
      detector, PLL + DLL despreading, CRC-8 header check, then the link layer
      (CRC-32, addressing, ACKs).  Several same-code bursts that overlap in time
      are decoded independently.

      Connect the ANTSDR source to its input.  Use the same node_id as the
      'CDMA Chat TX' block of this station.
      """
      import os
      import sys
      import numpy as np
      from gnuradio import gr

      # Make the cdmachat package importable: this file is generated next to the .grc,
      # and the .grc lives in <project>/grc/.
      _HERE = os.path.dirname(os.path.abspath(globals().get("__file__", os.getcwd() + "/x")))
      for _cand in (os.path.join(_HERE, ".."), _HERE, os.getcwd(), os.path.join(os.getcwd(), "..")):
          if os.path.isdir(os.path.join(_cand, "cdmachat")):
              sys.path.insert(0, os.path.abspath(_cand))
              break


      class blk(gr.sync_block):
          def __init__(self, node_id=1, station_name="Alice", web_port=8080, enc_key="",
                       samp_rate=4e6, center_freq=2.5e9, tx_buffer=131072, profile="fast",
                       mod_policy="auto", mode="antsdr"):
              gr.sync_block.__init__(self, name="CDMA Chat RX", in_sig=[np.complex64], out_sig=None)
              self.args = (int(node_id), station_name, int(web_port), enc_key, float(samp_rate),
                           float(center_freq), int(tx_buffer))
              self.kw = dict(profile=profile, mod_policy=mod_policy)
              self.mode = mode
              self.station = None

          def start(self):
              from cdmachat.grc_glue import get_station
              self.station = get_station(*self.args, mode=self.mode, **self.kw)
              self.station.start()
              return True

          def stop(self):
              if self.station is not None:
                  self.station.stop()
                  self.station = None
              return True

          def work(self, input_items, output_items):
              if self.station is not None:
                  self.station.radio.rx_push(input_items[0])
              return len(input_items[0])
    node_id: '2'
    station_name: '''Bob'''
    web_port: '8082'
    enc_key: ''''''
    samp_rate: samp_rate
    center_freq: center_freq
    tx_buffer: tx_buffer
    profile: '''fast'''
    mod_policy: '''auto'''
    mode: '''grc-sim'''
  states: {}
- name: air_spectrum
  id: qtgui_freq_sink_x
  parameters:
    type: complex
    name: '"Shared channel spectrum"'
    fftsize: '1024'
    fc: '0'
    bw: samp_rate
    ymin: '-120'
    ymax: '-10'
    average: '0.2'
    gui_hint: 2,0,1,2
    grid: 'True'
    label1: ''''''
  states: {}
- name: air_scope
  id: qtgui_time_sink_x
  parameters:
    type: complex
    name: '"Shared channel (time)"'
    size: '40000'
    srate: samp_rate
    ymin: '-1.5'
    ymax: '1.5'
    update_time: '0.2'
    gui_hint: 3,0,1,2
    label1: '''I'''
    label2: '''Q'''
    entags: 'False'
  states: {}

connections:
- [alice_tx, '0', air_sum, '0']
- [bob_tx, '0', air_sum, '1']
- [air_sum, '0', throttle, '0']
- [throttle, '0', channel, '0']
- [channel, '0', alice_rx, '0']
- [channel, '0', bob_rx, '0']
- [channel, '0', air_spectrum, '0']
- [channel, '0', air_scope, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
