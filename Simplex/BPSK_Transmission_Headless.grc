options:
  parameters:
    author: Barry Duggan
    generate_options: no_gui
    id: BPSK_Transmission_Headless
    output_language: python
    title: BPSK_Transmission_Headless
  states: {}

blocks:
- name: constel
  id: variable_constellation
  parameters:
    precision: '8'
    type: bpsk
  states: {}
- name: frequency
  id: variable
  parameters:
    value: 905.2e6
  states: {}
- name: hdr
  id: variable
  parameters:
    value: digital.header_format_default(digital.packet_utils.default_access_code, 0)
  states: {}
- name: payload_size
  id: variable
  parameters:
    value: '1024'
  states: {}
- name: postamble_size
  id: variable
  parameters:
    value: '10000'
  states: {}
- name: preamble_size
  id: variable
  parameters:
    value: '384'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '2000000'
  states: {}
- name: sps
  id: variable
  parameters:
    value: '4'
  states: {}
- name: tx_atten
  id: variable
  parameters:
    comment: 'NOTE: attenuation!'
    value: '10'
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/pxn-ai/Downloads/color_test_800x600_118kb.jpg
    repeat: 'False'
    type: byte
  states: {state: disabled}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '0.5'
    type: complex
  states: {}
- name: blocks_stream_to_tagged_stream_0_0_0
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: '"packet_len"'
    packet_len: payload_size
    type: byte
  states: {state: disabled}
- name: blocks_stream_to_tagged_stream_0_0_0_0
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: '"packet_len"'
    packet_len: preamble_size
    type: byte
  states: {}
- name: blocks_stream_to_tagged_stream_0_0_0_0_0
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: '"packet_len"'
    packet_len: postamble_size
    type: byte
  states: {state: disabled}
- name: blocks_tagged_stream_mux_0
  id: blocks_tagged_stream_mux
  parameters:
    lengthtagname: packet_len
    ninputs: '3'
    type: byte
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {state: disabled}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    comment: Preamble
    repeat: 'True'
    type: byte
    vector: '[0xc0, 0xaf]'
  states: {}
- name: blocks_vector_source_x_0_0
  id: blocks_vector_source_x
  parameters:
    comment: Postamble
    repeat: 'True'
    type: byte
    vector: '[0xc0, 0xaf]'
  states: {state: disabled}
- name: digital_constellation_modulator_0
  id: digital_constellation_modulator
  parameters:
    constellation: constel
    differential: 'True'
    excess_bw: '0.35'
    samples_per_symbol: sps
  states: {}
- name: digital_crc32_bb_0
  id: digital_crc32_bb
  parameters:
    check: 'False'
    lengthtagname: '"packet_len"'
    packed: 'True'
  states: {}
- name: digital_protocol_formatter_bb_0
  id: digital_protocol_formatter_bb
  parameters:
    format: hdr
    len_tag_key: packet_len
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr
      import pmt

      class blk(gr.sync_block):
          def __init__(self):
              gr.sync_block.__init__(self, name='Text to PDU', in_sig=None, out_sig=None)
              self.message_port_register_in(pmt.intern('msg_in'))
              self.message_port_register_out(pmt.intern('pdu_out'))
              self.set_msg_handler(pmt.intern('msg_in'), self.handle_msg)

          def handle_msg(self, msg):
              text = ""
              
              # Extract text from the PMT dictionary sent by tx_server.py
              if pmt.is_pair(msg):
                  meta = pmt.car(msg)
                  if pmt.is_dict(meta) and pmt.dict_has_key(meta, pmt.intern("text")):
                      text_pmt = pmt.dict_ref(meta, pmt.intern("text"), pmt.PMT_NIL)
                      if pmt.is_symbol(text_pmt):
                          text = pmt.symbol_to_string(text_pmt)
              # Fallback if raw symbol is sent directly
              elif pmt.is_symbol(msg):
                  text = pmt.symbol_to_string(msg)

              if not text:
                  return

              text += '\n'
              
              # --- PACKET 1: The Real Message ---
              bytes_list = list(text.encode('utf-8'))
              if len(bytes_list) < 1024:
                  bytes_list.extend([32] * (1024 - len(bytes_list)))
              
              pdu_real = pmt.cons(pmt.make_dict(), pmt.init_u8vector(len(bytes_list), bytes_list))
              self.message_port_pub(pmt.intern('pdu_out'), pdu_real)
              
              # --- PACKET 2: The Dummy Flush Packet ---
              flush_list = [32] * 1024 
              pdu_flush = pmt.cons(pmt.make_dict(), pmt.init_u8vector(len(flush_list), flush_list))
              self.message_port_pub(pmt.intern('pdu_out'), pdu_flush)
  states: {}
- name: iio_pluto_sink_0
  id: iio_pluto_sink
  parameters:
    attenuation1: tx_atten
    bandwidth: samp_rate
    buffer_size: '32768'
    cyclic: 'False'
    filter_source: '''Auto'''
    frequency: int(frequency)
    samplerate: int(samp_rate)
    type: fc32
    uri: '"ip:192.168.1.10"'
  states: {}
- name: pdu_pdu_to_tagged_stream_0
  id: pdu_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: snippet_0
  id: snippet
  parameters:
    code: |-
      with open("bpsk_transmit.txt", "w") as f:
      	payload = "Hello World! \n \t - from WaveLink"
      	f.write(payload)
    comment: Create transmit file
    section: init_before_blocks
  states: {}
- name: virtual_sink_0_0
  id: virtual_sink
  parameters:
    stream_id: header
  states: {}
- name: virtual_sink_2_0
  id: virtual_sink
  parameters:
    stream_id: payload
  states: {}
- name: virtual_source_5
  id: virtual_source
  parameters:
    stream_id: header
  states: {}
- name: virtual_source_6
  id: virtual_source
  parameters:
    stream_id: payload
  states: {}
- name: xmlrpc_server_0
  id: xmlrpc_server
  parameters:
    addr: 127.0.0.1
    port: '8081'
  states: {}
- name: zeromq_pub_sink_0
  id: zeromq_pub_sink
  parameters:
    address: '"tcp://*:5555"'
    timeout: '100'
    type: complex
  states: {state: disabled}
- name: zeromq_pub_sink_iq
  id: zeromq_pub_sink
  parameters:
    address: '"tcp://127.0.0.1:5003"'
    timeout: '100'
    type: complex
  states: {}
- name: zeromq_pull_msg_source_0
  id: zeromq_pull_msg_source
  parameters:
    address: '"tcp://127.0.0.1:5001"'
    timeout: '100'
  states: {}

connections:
- [blocks_file_source_0, '0', blocks_stream_to_tagged_stream_0_0_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_throttle2_0, '0']
- [blocks_multiply_const_vxx_0, '0', iio_pluto_sink_0, '0']
- [blocks_multiply_const_vxx_0, '0', zeromq_pub_sink_iq, '0']
- [blocks_stream_to_tagged_stream_0_0_0, '0', digital_crc32_bb_0, '0']
- [blocks_stream_to_tagged_stream_0_0_0_0, '0', blocks_tagged_stream_mux_0, '0']
- [blocks_tagged_stream_mux_0, '0', digital_constellation_modulator_0, '0']
- [blocks_throttle2_0, '0', zeromq_pub_sink_0, '0']
- [blocks_vector_source_x_0, '0', blocks_stream_to_tagged_stream_0_0_0_0, '0']
- [blocks_vector_source_x_0_0, '0', blocks_stream_to_tagged_stream_0_0_0_0_0, '0']
- [digital_constellation_modulator_0, '0', blocks_multiply_const_vxx_0, '0']
- [digital_crc32_bb_0, '0', digital_protocol_formatter_bb_0, '0']
- [digital_crc32_bb_0, '0', virtual_sink_2_0, '0']
- [digital_protocol_formatter_bb_0, '0', virtual_sink_0_0, '0']
- [epy_block_0, pdu_out, pdu_pdu_to_tagged_stream_0, pdus]
- [pdu_pdu_to_tagged_stream_0, '0', digital_crc32_bb_0, '0']
- [virtual_source_5, '0', blocks_tagged_stream_mux_0, '1']
- [virtual_source_6, '0', blocks_tagged_stream_mux_0, '2']
- [zeromq_pull_msg_source_0, out, epy_block_0, msg_in]

metadata:
  file_format: 1
  grc_version: 3.10.12.0
