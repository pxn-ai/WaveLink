options:
  parameters:
    author: WaveLink
    description: DS-CDMA BPSK/QPSK/16-QAM physical layer of one station
    generate_options: no_gui
    id: cdma_phy
    output_language: python
    run_options: run
    title: WaveLink Chat - physical layer (ANTSDR E200)
  states: {}

blocks:
- name: note_about
  id: note
  parameters:
    note: |-
      PHYSICAL LAYER of one WaveLink Chat station. The chat app compiles this file with grcc, runs it and attaches its link layer to the 'MAC -> PHY' and
      'PHY -> MAC' blocks. Every station uses the same file with its own Node ID (1-4 = its Gold code). ANTSDR E200 with the Pluto (libiio) firmware,
      carrier 2.5 GHz, DS-CDMA with 31-chip Gold codes, payload BPSK, QPSK or 16-QAM chosen per frame by the link layer.
  states: {}
- name: node_id
  id: parameter
  parameters:
    label: Node ID (= Gold code)
    type: intx
    value: '1'
    short_id: i
  states: {}
- name: uri
  id: parameter
  parameters:
    label: ANTSDR URI
    type: str
    value: ip:192.168.1.10
    short_id: u
  states: {}
- name: center_freq
  id: parameter
  parameters:
    label: Carrier (Hz)
    type: eng_float
    value: 2.5e9
    short_id: f
  states: {}
- name: rx_gain
  id: parameter
  parameters:
    label: RX gain (dB)
    type: eng_float
    value: '40'
    short_id: g
  states: {}
- name: tx_atten
  id: parameter
  parameters:
    label: TX attenuation (dB)
    type: eng_float
    value: '10'
    short_id: a
  states: {}
- name: tx_buffer
  id: parameter
  parameters:
    label: TX buffer (samples)
    type: intx
    value: '131072'
    short_id: b
  states: {}
- name: imports
  id: import_
  parameters:
    imports: |-
      from gnuradio.filter import firdes
      import pmt
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 4e6
    comment: ANTSDR sample rate (S/s)
  states: {}
- name: sps
  id: variable
  parameters:
    value: '2'
    comment: samples per chip
  states: {}
- name: chip_rate
  id: variable
  parameters:
    value: samp_rate / sps
  states: {}
- name: sf
  id: variable
  parameters:
    value: '31'
    comment: |-
      spreading factor =
      Gold code length
  states: {}
- name: gold_degree
  id: variable
  parameters:
    value: '5'
  states: {}
- name: preamble_bits
  id: variable
  parameters:
    value: '48'
  states: {}
- name: max_payload
  id: variable
  parameters:
    value: '1024'
    comment: |-
      max bytes per burst
      (MAC frame + CRC-32)
  states: {}
- name: rolloff
  id: variable
  parameters:
    value: '0.35'
    comment: RRC roll-off
  states: {}
- name: ldpc_max_iter
  id: variable
  parameters:
    value: '20'
    comment: |-
      LDPC decoder: max
      min-sum iterations
      (stops early when
      all checks pass)
  states: {}
- name: rrc_taps
  id: variable
  parameters:
    value: firdes.root_raised_cosine(sps, sps, 1.0, rolloff, 8 * sps + 1)
    comment: root-raised-cosine chip pulse
  states: {}
- name: tx_scale
  id: variable
  parameters:
    value: 0.25 / (sum(t * t for t in rrc_taps) / sps) ** 0.5
    comment: |-
      RMS 0.25 per code lane:
      headroom for 16-QAM peaks
      and several lanes at once
  states: {}
- name: code_0
  id: variable
  parameters:
    value: '[-1, -1, -1, -1, -1, +1, +1, -1, -1, +1, -1, +1, +1, -1, +1, +1, +1, +1, -1, +1, -1, +1, -1, -1, -1, +1, -1, -1, +1, +1, +1]'
    comment: 'Gold code #0 (broadcast)'
  states: {}
- name: code_1
  id: variable
  parameters:
    value: '[-1, -1, -1, -1, -1, +1, +1, -1, +1, +1, -1, -1, +1, +1, +1, +1, -1, +1, -1, -1, +1, -1, +1, -1, +1, +1, +1, -1, -1, -1, +1]'
    comment: 'Gold code #1 (node 1)'
  states: {}
- name: code_2
  id: variable
  parameters:
    value: '[-1, -1, +1, -1, -1, -1, -1, -1, -1, +1, -1, -1, +1, +1, -1, +1, -1, +1, +1, +1, -1, +1, +1, +1, +1, +1, +1, +1, -1, -1, -1]'
    comment: 'Gold code #2 (node 2)'
  states: {}
- name: code_3
  id: variable
  parameters:
    value: '[-1, +1, -1, -1, +1, -1, +1, -1, -1, +1, +1, +1, -1, +1, +1, -1, +1, -1, -1, +1, -1, -1, +1, +1, -1, -1, +1, +1, -1, -1, +1]'
    comment: 'Gold code #3 (node 3)'
  states: {}
- name: code_4
  id: variable
  parameters:
    value: '[+1, -1, -1, +1, +1, +1, +1, -1, -1, -1, -1, -1, -1, -1, -1, +1, -1, +1, -1, +1, +1, -1, +1, -1, +1, -1, +1, +1, -1, +1, +1]'
    comment: 'Gold code #4 (node 4)'
  states: {}
- name: const_bpsk
  id: variable_constellation
  parameters:
    type: calcdist
    const_points: '[1+0j, -1+0j]'
    sym_map: '[0, 1]'
    rot_sym: '2'
    dims: '1'
    normalization: digital.constellation.POWER_NORMALIZATION
    precision: '8'
  states: {}
- name: const_qpsk
  id: variable_constellation
  parameters:
    type: calcdist
    const_points: '[1+1j, 1-1j, -1+1j, -1-1j]'
    sym_map: '[0, 1, 2, 3]'
    rot_sym: '4'
    dims: '1'
    normalization: digital.constellation.POWER_NORMALIZATION
    precision: '8'
    comment: 'Gray: index = bits'
  states: {}
- name: const_16qam
  id: variable_constellation
  parameters:
    type: calcdist
    const_points: '[(-3-3j), (-3-1j), (-3+3j), (-3+1j), (-1-3j), (-1-1j), (-1+3j), (-1+1j), (3-3j), (3-1j), (3+3j), (3+1j), (1-3j), (1-1j), (1+3j), (1+1j)]'
    sym_map: '[0, 1, 2, 3, 4, 5, 6, 7, 8, 9, 10, 11, 12, 13, 14, 15]'
    rot_sym: '4'
    dims: '1'
    normalization: digital.constellation.POWER_NORMALIZATION
    precision: '8'
    npwr: '0.05'
    comment: |-
      Gray: index = bits
      (I = bits 0-1, Q = bits 2-3)
      npwr 0.05: soft bits shaped
      for ~13 dB (max-log-like)
  states: {}
- name: sym_table
  id: variable
  parameters:
    value: list(const_bpsk.points()) + list(const_qpsk.points()) + list(const_16qam.points())
    comment: |-
      combined table for the TX
      Chunks to Symbols blocks:
      0-1 BPSK, 2-5 QPSK, 6-21 16-QAM
  states: {}
- name: note_tx
  id: note
  parameters:
    note: |-
      TRANSMITTER: MAC frame -> CRC-32 -> LDPC Encoder (5G NR code, rate 1/2, 2/3, 3/4, 5/6 or uncoded, chosen per frame by
      the link layer) -> CDMA PHY Framer (48 preamble symbols, Golay-coded header, payload as constellation indices) -> one
      lane per Gold code: Chunks to Symbols (BPSK / QPSK / 16-QAM), Repeat x31 and Multiply by the code = spreading -> Burst
      Combiner (adds the lanes, zero-fills) -> RRC pulse shaping -> ANTSDR at 2.5 GHz
  states: {}
- name: mac_tx
  id: epy_block
  parameters:
    _source_code: |
      """
      MAC -> PHY (from app)

      Entry point of the physical layer.  The chat application's link layer calls
      submit(frame, code, mod) on this block; it publishes the MAC frame as a PDU
      whose metadata says which Gold code to spread it with (= destination station,
      0 = broadcast) and which modulation and coding to use: bpsk | qpsk | 16qam,
      plus an LDPC code rate, e.g. '16qam-3/4' (no rate = uncoded), and 'pwr': the
      burst's power in dB relative to full power (transmit power control, <= 0).
      """
      import os
      import sys
      import numpy as np
      import pmt
      from gnuradio import gr


      def _project():
          """Make the wavelink package importable (this file is generated into grc/ or build/grc/)."""
          here = os.path.dirname(os.path.abspath(globals().get("__file__", os.path.join(os.getcwd(), "x"))))
          for cand in (here, os.path.join(here, ".."), os.path.join(here, "..", ".."),
                       os.getcwd(), os.path.join(os.getcwd(), "..")):
              if os.path.isdir(os.path.join(cand, "wavelink")):
                  cand = os.path.abspath(cand)
                  if cand not in sys.path:
                      sys.path.insert(0, cand)
                  return True
          return "wavelink" in sys.modules


      def _register(node_id, role, obj):
          try:
              if _project():
                  from wavelink.grc_phy import register
                  register(node_id, role, obj)
          except ImportError:
              pass                     # opened in GNU Radio Companion outside the project: ports only


      class blk(gr.sync_block):
          def __init__(self, node_id=1):
              gr.sync_block.__init__(self, name="MAC -> PHY (from app)", in_sig=None, out_sig=None)
              self.node_id = int(node_id)
              self.port = pmt.intern("pdus")
              self.message_port_register_out(self.port)
              _register(self.node_id, "mac_tx", self)

          def submit(self, frame, code, mod, gain_db=0.0):
              meta = pmt.make_dict()
              meta = pmt.dict_add(meta, pmt.intern("code"), pmt.from_long(int(code)))
              meta = pmt.dict_add(meta, pmt.intern("mod"), pmt.intern(str(mod)))
              meta = pmt.dict_add(meta, pmt.intern("pwr"), pmt.from_double(float(gain_db)))
              self.message_port_pub(self.port, pmt.cons(meta, pmt.init_u8vector(len(frame), list(frame))))
    node_id: node_id
  states: {}
- name: tx_stream
  id: pdu_pdu_to_tagged_stream
  parameters:
    type: byte
    tag: packet_len
  states: {}
- name: tx_crc
  id: digital_crc32_bb
  parameters:
    check: 'False'
    lengthtagname: '"packet_len"'
    packed: 'True'
    comment: append CRC-32
  states: {}
- name: tx_pdu
  id: pdu_tagged_stream_to_pdu
  parameters:
    type: byte
    tag: packet_len
  states: {}
- name: ldpc_enc
  id: epy_block
  parameters:
    _source_code: |
      """
      LDPC Encoder

      Forward error correction for the payload: the 5G NR LDPC code (3GPP TS 38.212,
      base graph 1).  Each MAC frame + CRC-32 is one codeword: filler bits up to
      22 x Z (Z = smallest 5G lifting size that fits), systematic encoding, then rate
      matching to the code rate the link layer asked for (1/2, 2/3, 3/4 or 5/6; the
      first 2 Z bits are punctured as in 5G) and the 5G bit interleaver for the
      modulation.  An uncoded frame ('16qam', 'qpsk', 'bpsk') passes as plain bits.

      Input PDU:  frame bytes, metadata code, mod = modulation-and-coding ('16qam-3/4')
      Output PDU: one byte per coded bit (0/1), metadata code, mod, rate, length
      """
      import os
      import sys
      import numpy as np
      import pmt
      from gnuradio import gr


      def _project():
          """Make the wavelink package importable (this file is generated into grc/ or build/grc/)."""
          here = os.path.dirname(os.path.abspath(globals().get("__file__", os.path.join(os.getcwd(), "x"))))
          for cand in (here, os.path.join(here, ".."), os.path.join(here, "..", ".."),
                       os.getcwd(), os.path.join(os.getcwd(), "..")):
              if os.path.isdir(os.path.join(cand, "wavelink")):
                  cand = os.path.abspath(cand)
                  if cand not in sys.path:
                      sys.path.insert(0, cand)
                  return True
          return "wavelink" in sys.modules


      def _register(node_id, role, obj):
          try:
              if _project():
                  from wavelink.grc_phy import register
                  register(node_id, role, obj)
          except ImportError:
              pass                     # opened in GNU Radio Companion outside the project: ports only


      class blk(gr.sync_block):
          def __init__(self, max_payload=1024):
              gr.sync_block.__init__(self, name="LDPC Encoder", in_sig=None, out_sig=None)
              self.max_payload = int(max_payload)
              self.port_in, self.port_out = pmt.intern("pdus"), pmt.intern("pdus")
              self.message_port_register_in(self.port_in)
              self.message_port_register_out(self.port_out)
              self.set_msg_handler(self.port_in, self.handle)
              self.core = None

          def start(self):
              _project()
              from wavelink.grc_phy import LdpcEncoderCore, phy_config
              self.core = LdpcEncoderCore(phy_config(4e6, 2, max_payload=self.max_payload))
              return True

          def handle(self, msg):
              if self.core is None:
                  self.start()
              meta, vec = pmt.car(msg), pmt.cdr(msg)
              frame = bytes(pmt.u8vector_elements(vec))
              mcs = pmt.symbol_to_string(pmt.dict_ref(meta, pmt.intern("mod"), pmt.intern("qpsk-1/2")))
              bits, mod, rate = self.core.encode(frame, mcs)
              meta = pmt.dict_add(meta, pmt.intern("mod"), pmt.intern(mod))
              meta = pmt.dict_add(meta, pmt.intern("rate"), pmt.from_long(int(rate)))
              meta = pmt.dict_add(meta, pmt.intern("length"), pmt.from_long(len(frame)))
              self.message_port_pub(self.port_out, pmt.cons(meta, pmt.init_u8vector(len(bits), bits.tolist())))
    max_payload: max_payload
  states: {}
- name: framer
  id: epy_block
  parameters:
    _source_code: |
      """
      CDMA PHY Framer

      Builds one burst per PDU and outputs it as constellation *indices* (one byte per
      symbol) for the Chunks-to-Symbols blocks of the code lanes:

        preamble   48 known BPSK symbols, different for every Gold code (burst detection,
                   timing, carrier phase and frequency estimation at the receiver)
        header     48 BPSK symbols: two Golay(24,12) codewords of 11-bit length,
                   2-bit modulation, 3-bit code rate, CRC-8
        payload    the LDPC Encoder's bits, Gray-mapped to BPSK (index 0-1), QPSK (2-5)
                   or 16-QAM (6-21) of the combined symbol table

      Output metadata 'code' selects the lane (spreading code) downstream; 'pwr' (the
      burst's power, from the MAC) becomes a stream tag that the Combiner applies.
      """
      import os
      import sys
      import numpy as np
      import pmt
      from gnuradio import gr


      def _project():
          """Make the wavelink package importable (this file is generated into grc/ or build/grc/)."""
          here = os.path.dirname(os.path.abspath(globals().get("__file__", os.path.join(os.getcwd(), "x"))))
          for cand in (here, os.path.join(here, ".."), os.path.join(here, "..", ".."),
                       os.getcwd(), os.path.join(os.getcwd(), "..")):
              if os.path.isdir(os.path.join(cand, "wavelink")):
                  cand = os.path.abspath(cand)
                  if cand not in sys.path:
                      sys.path.insert(0, cand)
                  return True
          return "wavelink" in sys.modules


      def _register(node_id, role, obj):
          try:
              if _project():
                  from wavelink.grc_phy import register
                  register(node_id, role, obj)
          except ImportError:
              pass                     # opened in GNU Radio Companion outside the project: ports only


      class blk(gr.sync_block):
          def __init__(self, gold_degree=5, preamble_bits=48, max_payload=1024):
              gr.sync_block.__init__(self, name="CDMA PHY Framer", in_sig=None, out_sig=None)
              self.args = (int(gold_degree), int(preamble_bits), int(max_payload))
              self.port_in, self.port_out = pmt.intern("pdus"), pmt.intern("pdus")
              self.message_port_register_in(self.port_in)
              self.message_port_register_out(self.port_out)
              self.set_msg_handler(self.port_in, self.handle)
              self.core = None

          def start(self):
              _project()
              from wavelink.grc_phy import FramerCore, phy_config
              g, k, m = self.args
              self.core = FramerCore(phy_config(4e6, 2, g, k, m))
              return True

          def handle(self, msg):
              if self.core is None:
                  self.start()
              meta, vec = pmt.car(msg), pmt.cdr(msg)
              code = pmt.to_long(pmt.dict_ref(meta, pmt.intern("code"), pmt.from_long(0)))
              mod = pmt.symbol_to_string(pmt.dict_ref(meta, pmt.intern("mod"), pmt.intern("bpskc")))
              rate = pmt.to_long(pmt.dict_ref(meta, pmt.intern("rate"), pmt.from_long(0)))
              length = pmt.to_long(pmt.dict_ref(meta, pmt.intern("length"), pmt.from_long(0)))
              bits = np.asarray(pmt.u8vector_elements(vec), dtype=np.int8)
              idx = self.core.indices(bits, length, code, mod, rate)
              out = pmt.dict_add(pmt.make_dict(), pmt.intern("code"), pmt.from_long(code))
              pwr = pmt.dict_ref(meta, pmt.intern("pwr"), pmt.PMT_NIL)
              if not pmt.is_null(pwr):
                  out = pmt.dict_add(out, pmt.intern("pwr"), pwr)
              self.message_port_pub(self.port_out, pmt.cons(out, pmt.init_u8vector(len(idx), idx.tolist())))
    gold_degree: gold_degree
    preamble_bits: preamble_bits
    max_payload: max_payload
  states: {}
- name: lane0_select
  id: pdu_pdu_filter
  parameters:
    k: pmt.intern("code")
    v: pmt.from_long(0)
    invert: 'False'
    comment: code 0 = broadcast
  states: {}
- name: lane0_stream
  id: pdu_pdu_to_tagged_stream
  parameters:
    type: byte
    tag: packet_len
    minoutbuf: '32768'
  states: {}
- name: lane0_map
  id: digital_chunks_to_symbols_xx
  parameters:
    in_type: byte
    out_type: complex
    symbol_table: sym_table
    dimension: '1'
  states: {}
- name: lane0_repeat
  id: blocks_repeat
  parameters:
    type: complex
    interp: sf
  states: {}
- name: lane0_code
  id: blocks_vector_source_x
  parameters:
    type: complex
    vector: code_0
    repeat: 'True'
  states: {}
- name: lane0_spread
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: lane0_len
  id: blocks_tagged_stream_multiply_length
  parameters:
    type: complex
    lengthtagname: '"packet_len"'
    c: sf
  states: {}
- name: lane1_select
  id: pdu_pdu_filter
  parameters:
    k: pmt.intern("code")
    v: pmt.from_long(1)
    invert: 'False'
    comment: bursts for node 1
  states: {}
- name: lane1_stream
  id: pdu_pdu_to_tagged_stream
  parameters:
    type: byte
    tag: packet_len
    minoutbuf: '32768'
  states: {}
- name: lane1_map
  id: digital_chunks_to_symbols_xx
  parameters:
    in_type: byte
    out_type: complex
    symbol_table: sym_table
    dimension: '1'
  states: {}
- name: lane1_repeat
  id: blocks_repeat
  parameters:
    type: complex
    interp: sf
  states: {}
- name: lane1_code
  id: blocks_vector_source_x
  parameters:
    type: complex
    vector: code_1
    repeat: 'True'
  states: {}
- name: lane1_spread
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: lane1_len
  id: blocks_tagged_stream_multiply_length
  parameters:
    type: complex
    lengthtagname: '"packet_len"'
    c: sf
  states: {}
- name: lane2_select
  id: pdu_pdu_filter
  parameters:
    k: pmt.intern("code")
    v: pmt.from_long(2)
    invert: 'False'
    comment: bursts for node 2
  states: {}
- name: lane2_stream
  id: pdu_pdu_to_tagged_stream
  parameters:
    type: byte
    tag: packet_len
    minoutbuf: '32768'
  states: {}
- name: lane2_map
  id: digital_chunks_to_symbols_xx
  parameters:
    in_type: byte
    out_type: complex
    symbol_table: sym_table
    dimension: '1'
  states: {}
- name: lane2_repeat
  id: blocks_repeat
  parameters:
    type: complex
    interp: sf
  states: {}
- name: lane2_code
  id: blocks_vector_source_x
  parameters:
    type: complex
    vector: code_2
    repeat: 'True'
  states: {}
- name: lane2_spread
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: lane2_len
  id: blocks_tagged_stream_multiply_length
  parameters:
    type: complex
    lengthtagname: '"packet_len"'
    c: sf
  states: {}
- name: lane3_select
  id: pdu_pdu_filter
  parameters:
    k: pmt.intern("code")
    v: pmt.from_long(3)
    invert: 'False'
    comment: bursts for node 3
  states: {}
- name: lane3_stream
  id: pdu_pdu_to_tagged_stream
  parameters:
    type: byte
    tag: packet_len
    minoutbuf: '32768'
  states: {}
- name: lane3_map
  id: digital_chunks_to_symbols_xx
  parameters:
    in_type: byte
    out_type: complex
    symbol_table: sym_table
    dimension: '1'
  states: {}
- name: lane3_repeat
  id: blocks_repeat
  parameters:
    type: complex
    interp: sf
  states: {}
- name: lane3_code
  id: blocks_vector_source_x
  parameters:
    type: complex
    vector: code_3
    repeat: 'True'
  states: {}
- name: lane3_spread
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: lane3_len
  id: blocks_tagged_stream_multiply_length
  parameters:
    type: complex
    lengthtagname: '"packet_len"'
    c: sf
  states: {}
- name: lane4_select
  id: pdu_pdu_filter
  parameters:
    k: pmt.intern("code")
    v: pmt.from_long(4)
    invert: 'False'
    comment: bursts for node 4
  states: {}
- name: lane4_stream
  id: pdu_pdu_to_tagged_stream
  parameters:
    type: byte
    tag: packet_len
    minoutbuf: '32768'
  states: {}
- name: lane4_map
  id: digital_chunks_to_symbols_xx
  parameters:
    in_type: byte
    out_type: complex
    symbol_table: sym_table
    dimension: '1'
  states: {}
- name: lane4_repeat
  id: blocks_repeat
  parameters:
    type: complex
    interp: sf
  states: {}
- name: lane4_code
  id: blocks_vector_source_x
  parameters:
    type: complex
    vector: code_4
    repeat: 'True'
  states: {}
- name: lane4_spread
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: lane4_len
  id: blocks_tagged_stream_multiply_length
  parameters:
    type: complex
    lengthtagname: '"packet_len"'
    c: sf
  states: {}
- name: combiner
  id: epy_block
  parameters:
    _source_code: |
      """
      CDMA Burst Combiner

      One input per code lane (chips of complete bursts, tagged with 'packet_len').
      Bursts on different codes are added together sample by sample (several links
      active at once on one carrier = CDMA); bursts on the same code follow each other.
      When no lane is sending, zeros are output so the radio always gets a continuous
      stream (the stock 'PDU to Stream' block stops instead, which starves the Pluto sink).
      Each burst is scaled by its 'pwr' tag (dB, transmit power control), which 'PDU to
      Tagged Stream' put on its first chip next to 'packet_len'.
      """
      import os
      import sys
      import numpy as np
      import pmt
      from gnuradio import gr


      def _project():
          """Make the wavelink package importable (this file is generated into grc/ or build/grc/)."""
          here = os.path.dirname(os.path.abspath(globals().get("__file__", os.path.join(os.getcwd(), "x"))))
          for cand in (here, os.path.join(here, ".."), os.path.join(here, "..", ".."),
                       os.getcwd(), os.path.join(os.getcwd(), "..")):
              if os.path.isdir(os.path.join(cand, "wavelink")):
                  cand = os.path.abspath(cand)
                  if cand not in sys.path:
                      sys.path.insert(0, cand)
                  return True
          return "wavelink" in sys.modules


      def _register(node_id, role, obj):
          try:
              if _project():
                  from wavelink.grc_phy import register
                  register(node_id, role, obj)
          except ImportError:
              pass                     # opened in GNU Radio Companion outside the project: ports only

      import collections


      class blk(gr.basic_block):
          def __init__(self, node_id=1, codes=(0, 1, 2, 3, 4), chip_rate=2e6, samp_rate=4e6,
                       tx_buffer=131072):
              self.codes = [int(c) for c in codes]
              gr.basic_block.__init__(self, name="CDMA Burst Combiner",
                                      in_sig=[np.complex64] * len(self.codes), out_sig=[np.complex64])
              self.node_id = int(node_id)
              self.len_key = pmt.intern("packet_len")
              self.pwr_key = pmt.intern("pwr")
              self.lens = [collections.deque() for _ in self.codes]
              self.bufs = [collections.deque() for _ in self.codes]
              self.have = [0] * len(self.codes)
              # produce in large chunks: each Python call has a fixed overhead, so fewer,
              # bigger calls keep the CPU load low (costs <= 4 ms of TX latency at 2 Mchip/s)
              self.set_output_multiple(8192)
              self.core = None
              try:
                  if _project():
                      from wavelink.grc_phy import CombinerCore
                      self.core = CombinerCore(float(chip_rate), int(tx_buffer), float(samp_rate))
                      _register(self.node_id, "combiner", self.core)
              except ImportError:
                  pass

          def forecast(self, noutput_items, ninputs):
              return [0] * ninputs                  # run even when every lane is idle

          def _take(self, i, n):
              parts, need = [], n
              while need:
                  b = self.bufs[i][0]
                  if b.size <= need:
                      parts.append(self.bufs[i].popleft())
                      need -= b.size
                  else:
                      parts.append(b[:need])
                      self.bufs[i][0] = b[need:]
                      need = 0
              self.have[i] -= n
              return np.concatenate(parts)

          def general_work(self, input_items, output_items):
              for i, x in enumerate(input_items):
                  n = len(x)
                  if not n:
                      continue
                  tags = self.get_tags_in_window(i, 0, n)
                  pwr = {t.offset: pmt.to_double(t.value) for t in tags if pmt.eq(t.key, self.pwr_key)}
                  for t in tags:
                      if pmt.eq(t.key, self.len_key):
                          self.lens[i].append((pmt.to_long(t.value), pwr.get(t.offset, 0.0)))
                  self.bufs[i].append(np.array(x, dtype=np.complex64))
                  self.have[i] += n
                  self.consume(i, n)
                  # only complete bursts are scheduled, so a burst is never cut by a gap
                  while self.lens[i] and self.have[i] >= self.lens[i][0][0]:
                      length, gain_db = self.lens[i].popleft()
                      burst = self._take(i, length)
                      if self.core is not None:
                          self.core.push(self.codes[i], burst, gain_db)
              out = output_items[0]
              if self.core is None:
                  out[:] = 0
              else:
                  self.core.read_into(out)
              return len(out)
    node_id: node_id
    codes: (0, 1, 2, 3, 4)
    chip_rate: chip_rate
    samp_rate: samp_rate
    tx_buffer: tx_buffer
  states: {}
- name: tx_rrc
  id: interp_fir_filter_xxx
  parameters:
    type: ccf
    interp: sps
    taps: rrc_taps
    comment: |-
      RRC pulse shaping
      (chips -> samples)
  states: {}
- name: tx_gain
  id: blocks_multiply_const_vxx
  parameters:
    type: complex
    const: tx_scale
  states: {}
- name: note_rx
  id: note
  parameters:
    note: |-
      RECEIVER: ANTSDR -> RRC matched filter -> CDMA Despreader (preamble correlation for this node's code and the broadcast
      code, carrier-offset estimate, DLL timing, despreading, Golay header, carrier tracking) -> one branch per modulation:
      Constellation Soft Decoder (soft bits) -> LDPC Decoder (min-sum) -> CRC-32 check (bad frames dropped) -> MAC
  states: {}
- name: rx_mf
  id: fft_filter_xxx
  parameters:
    type: ccf
    decim: '1'
    taps: rrc_taps
    comment: RRC matched filter
  states: {}
- name: despreader
  id: epy_block
  parameters:
    _source_code: |
      """
      CDMA Despreader

      Input: received samples after the RRC matched filter.
      For this station's Gold code and the broadcast code it
        1. correlates with the code-specific preamble (differential detector: works
           with carrier frequency offset) -> burst start, timing, coarse CFO
        2. removes the CFO, despreads (x code, sum over 31 chips) with fractional-delay
           timing and an early-late DLL that follows the clock offset between radios
        3. decodes the header coherently (two Golay(24,12) words, soft ML decoding):
           length, modulation, code rate, CRC-8
        4. tracks the carrier phase over the payload (decision-directed loop anchored
           on the known preamble and header)
      and outputs one PDU per burst: the despread payload symbols, normalised to the
      unit-energy constellation, with metadata mod / rate / length / code / snr_db /
      esn0_db / cfo_hz.  The stock Constellation Soft Decoder blocks downstream turn
      them into soft bits for the LDPC Decoder.
      """
      import os
      import sys
      import numpy as np
      import pmt
      from gnuradio import gr


      def _project():
          """Make the wavelink package importable (this file is generated into grc/ or build/grc/)."""
          here = os.path.dirname(os.path.abspath(globals().get("__file__", os.path.join(os.getcwd(), "x"))))
          for cand in (here, os.path.join(here, ".."), os.path.join(here, "..", ".."),
                       os.getcwd(), os.path.join(os.getcwd(), "..")):
              if os.path.isdir(os.path.join(cand, "wavelink")):
                  cand = os.path.abspath(cand)
                  if cand not in sys.path:
                      sys.path.insert(0, cand)
                  return True
          return "wavelink" in sys.modules


      def _register(node_id, role, obj):
          try:
              if _project():
                  from wavelink.grc_phy import register
                  register(node_id, role, obj)
          except ImportError:
              pass                     # opened in GNU Radio Companion outside the project: ports only


      class blk(gr.sync_block):
          def __init__(self, node_id=1, samp_rate=4e6, sps=2, gold_degree=5, preamble_bits=48,
                       max_payload=1024):
              gr.sync_block.__init__(self, name="CDMA Despreader", in_sig=[np.complex64], out_sig=None)
              self.node_id = int(node_id)
              self.port = pmt.intern("pdus")
              self.message_port_register_out(self.port)
              self.set_output_multiple(16384)        # hand samples over in big chunks (less overhead)
              self.core = None
              try:
                  if _project():
                      from wavelink.grc_phy import DespreaderCore, phy_config
                      cfg = phy_config(samp_rate, sps, gold_degree, preamble_bits, max_payload)
                      self.core = DespreaderCore(cfg, self.node_id, self._publish)
                      _register(self.node_id, "despreader", self.core)
              except ImportError:
                  pass

          def _publish(self, f):
              mod = "bpsk" if f.mod in ("bpsk", "bpskc") else f.mod
              meta = pmt.make_dict()
              for k, v in (("mod", pmt.intern(mod)), ("code", pmt.from_long(int(f.code_idx))),
                           ("rate", pmt.from_long(int(f.rate))), ("length", pmt.from_long(int(f.length))),
                           ("mcs", pmt.intern(f.mcs)),
                           ("snr_db", pmt.from_double(float(f.snr_db))),
                           ("esn0_db", pmt.from_double(float(f.esn0_db))),
                           ("cfo_hz", pmt.from_double(float(f.cfo_hz))),
                           ("metric", pmt.from_double(float(f.metric)))):
                  meta = pmt.dict_add(meta, pmt.intern(k), v)
              s = f.symbols
              self.message_port_pub(self.port, pmt.cons(meta, pmt.init_c32vector(len(s), s.tolist())))

          def start(self):
              if self.core is not None:
                  self.core.start()
              return True

          def stop(self):
              if self.core is not None:
                  self.core.stop()
              return True

          def work(self, input_items, output_items):
              if self.core is not None:
                  self.core.push(input_items[0])
              return len(input_items[0])
    node_id: node_id
    samp_rate: samp_rate
    sps: sps
    gold_degree: gold_degree
    preamble_bits: preamble_bits
    max_payload: max_payload
  states: {}
- name: rx_bpsk_select
  id: pdu_pdu_filter
  parameters:
    k: pmt.intern("mod")
    v: pmt.intern("bpsk")
    invert: 'False'
    comment: BPSK bursts
  states: {}
- name: rx_bpsk_stream
  id: pdu_pdu_to_tagged_stream
  parameters:
    type: complex
    tag: packet_len
    minoutbuf: '32768'
    comment: |-
      buffer holds a whole burst
      (1 KB BPSK-1/2 = 16.5k symbols)
  states: {}
- name: rx_bpsk_soft
  id: digital_constellation_soft_decoder_cf
  parameters:
    constellation: const_bpsk
    npwr: '-1'
    minoutbuf: '32768'
    comment: 1 soft bit per symbol
  states: {}
- name: rx_bpsk_len
  id: blocks_tagged_stream_multiply_length
  parameters:
    type: float
    lengthtagname: '"packet_len"'
    c: '1'
    minoutbuf: '32768'
  states: {}
- name: rx_bpsk_pdu
  id: pdu_tagged_stream_to_pdu
  parameters:
    type: float
    tag: packet_len
  states: {}
- name: rx_qpsk_select
  id: pdu_pdu_filter
  parameters:
    k: pmt.intern("mod")
    v: pmt.intern("qpsk")
    invert: 'False'
    comment: QPSK bursts
  states: {}
- name: rx_qpsk_stream
  id: pdu_pdu_to_tagged_stream
  parameters:
    type: complex
    tag: packet_len
    minoutbuf: '32768'
    comment: |-
      buffer holds a whole burst
      (1 KB BPSK-1/2 = 16.5k symbols)
  states: {}
- name: rx_qpsk_soft
  id: digital_constellation_soft_decoder_cf
  parameters:
    constellation: const_qpsk
    npwr: '-1'
    minoutbuf: '32768'
    comment: 2 soft bits per symbol
  states: {}
- name: rx_qpsk_len
  id: blocks_tagged_stream_multiply_length
  parameters:
    type: float
    lengthtagname: '"packet_len"'
    c: '2'
    minoutbuf: '32768'
  states: {}
- name: rx_qpsk_pdu
  id: pdu_tagged_stream_to_pdu
  parameters:
    type: float
    tag: packet_len
  states: {}
- name: rx_qam16_select
  id: pdu_pdu_filter
  parameters:
    k: pmt.intern("mod")
    v: pmt.intern("16qam")
    invert: 'False'
    comment: 16QAM bursts
  states: {}
- name: rx_qam16_stream
  id: pdu_pdu_to_tagged_stream
  parameters:
    type: complex
    tag: packet_len
    minoutbuf: '32768'
    comment: |-
      buffer holds a whole burst
      (1 KB BPSK-1/2 = 16.5k symbols)
  states: {}
- name: rx_qam16_soft
  id: digital_constellation_soft_decoder_cf
  parameters:
    constellation: const_16qam
    npwr: '-1'
    minoutbuf: '32768'
    comment: 4 soft bits per symbol
  states: {}
- name: rx_qam16_len
  id: blocks_tagged_stream_multiply_length
  parameters:
    type: float
    lengthtagname: '"packet_len"'
    c: '4'
    minoutbuf: '32768'
  states: {}
- name: rx_qam16_pdu
  id: pdu_tagged_stream_to_pdu
  parameters:
    type: float
    tag: packet_len
  states: {}
- name: ldpc_dec
  id: epy_block
  parameters:
    _source_code: |
      """
      LDPC Decoder

      Input PDUs: the soft bits of one burst's payload from a stock Constellation Soft
      Decoder (log P(1)/P(0) per bit), metadata mod, rate, length and the receiver's
      measurements.  Undoes the bit interleaver and rate matching, then decodes the
      5G NR LDPC codeword with a layered normalised min-sum decoder (scale invariant,
      so it needs no noise estimate; early stop when every parity check is met;
      at most 'Max iterations').  Uncoded frames get hard decisions.

      Output PDU: the frame bytes incl. CRC-32 (checked by the stock block after this),
      metadata + fec_iters.
      """
      import os
      import sys
      import numpy as np
      import pmt
      from gnuradio import gr


      def _project():
          """Make the wavelink package importable (this file is generated into grc/ or build/grc/)."""
          here = os.path.dirname(os.path.abspath(globals().get("__file__", os.path.join(os.getcwd(), "x"))))
          for cand in (here, os.path.join(here, ".."), os.path.join(here, "..", ".."),
                       os.getcwd(), os.path.join(os.getcwd(), "..")):
              if os.path.isdir(os.path.join(cand, "wavelink")):
                  cand = os.path.abspath(cand)
                  if cand not in sys.path:
                      sys.path.insert(0, cand)
                  return True
          return "wavelink" in sys.modules


      def _register(node_id, role, obj):
          try:
              if _project():
                  from wavelink.grc_phy import register
                  register(node_id, role, obj)
          except ImportError:
              pass                     # opened in GNU Radio Companion outside the project: ports only


      class blk(gr.sync_block):
          def __init__(self, node_id=1, max_iter=20):
              gr.sync_block.__init__(self, name="LDPC Decoder", in_sig=None, out_sig=None)
              self.node_id = int(node_id)
              self.port_in, self.port_out = pmt.intern("pdus"), pmt.intern("pdus")
              self.message_port_register_in(self.port_in)
              self.message_port_register_out(self.port_out)
              self.set_msg_handler(self.port_in, self.handle)
              self.core = None
              try:
                  if _project():
                      from wavelink.grc_phy import LdpcDecoderCore
                      self.core = LdpcDecoderCore(max_iter)
                      _register(self.node_id, "ldpc_decoder", self.core)
              except ImportError:
                  pass

          def handle(self, msg):
              if self.core is None:
                  return
              meta, vec = pmt.car(msg), pmt.cdr(msg)
              get = lambda k, d: pmt.to_python(pmt.dict_ref(meta, pmt.intern(k), pmt.to_pmt(d)))  # noqa: E731
              soft = np.asarray(pmt.f32vector_elements(vec), dtype=np.float32)
              data, ok, it = self.core.decode(soft, int(get("length", 0)), str(get("mod", "qpsk")),
                                              int(get("rate", 0)))
              meta = pmt.dict_add(meta, pmt.intern("fec_iters"), pmt.from_long(int(it)))
              meta = pmt.dict_add(meta, pmt.intern("fec_ok"), pmt.from_bool(bool(ok)))
              self.message_port_pub(self.port_out, pmt.cons(meta, pmt.init_u8vector(len(data), list(data))))
    node_id: node_id
    max_iter: ldpc_max_iter
  states: {}
- name: rx_bytes
  id: pdu_pdu_to_tagged_stream
  parameters:
    type: byte
    tag: packet_len
  states: {}
- name: rx_crc
  id: digital_crc32_bb
  parameters:
    check: 'True'
    lengthtagname: '"packet_len"'
    packed: 'True'
    comment: |-
      check + strip CRC-32
      (bad frames dropped)
  states: {}
- name: rx_pdu
  id: pdu_tagged_stream_to_pdu
  parameters:
    type: byte
    tag: packet_len
  states: {}
- name: mac_rx
  id: epy_block
  parameters:
    _source_code: |
      """
      PHY -> MAC (to app)

      Exit point of the physical layer: frames that passed the CRC-32 check, with the
      receiver's metadata (code, modulation and code rate, SNR, carrier offset,
      LDPC iterations).  The chat
      application's link layer installs a handler here; when the flowgraph is run on
      its own (e.g. from GNU Radio Companion) received frames are just printed.
      """
      import os
      import sys
      import numpy as np
      import pmt
      from gnuradio import gr


      def _project():
          """Make the wavelink package importable (this file is generated into grc/ or build/grc/)."""
          here = os.path.dirname(os.path.abspath(globals().get("__file__", os.path.join(os.getcwd(), "x"))))
          for cand in (here, os.path.join(here, ".."), os.path.join(here, "..", ".."),
                       os.getcwd(), os.path.join(os.getcwd(), "..")):
              if os.path.isdir(os.path.join(cand, "wavelink")):
                  cand = os.path.abspath(cand)
                  if cand not in sys.path:
                      sys.path.insert(0, cand)
                  return True
          return "wavelink" in sys.modules


      def _register(node_id, role, obj):
          try:
              if _project():
                  from wavelink.grc_phy import register
                  register(node_id, role, obj)
          except ImportError:
              pass                     # opened in GNU Radio Companion outside the project: ports only


      class blk(gr.sync_block):
          def __init__(self, node_id=1):
              gr.sync_block.__init__(self, name="PHY -> MAC (to app)", in_sig=None, out_sig=None)
              self.node_id = int(node_id)
              self.port = pmt.intern("pdus")
              self.message_port_register_in(self.port)
              self.set_msg_handler(self.port, self.handle)
              self.handler = None
              _register(self.node_id, "mac_rx", self)

          def handle(self, msg):
              meta = pmt.to_python(pmt.car(msg)) or {}
              data = bytes(pmt.u8vector_elements(pmt.cdr(msg)))
              if self.handler is not None:
                  self.handler(meta, data)
              else:
                  print(f"[node {self.node_id}] rx {len(data)} B  {meta.get('mcs') or meta.get('mod')} "
                        f"code={meta.get('code')} Es/N0={meta.get('esn0_db', 0):.1f} dB", flush=True)
    node_id: node_id
  states: {}
- name: antsdr_tx
  id: iio_pluto_sink
  parameters:
    type: fc32
    uri: uri
    frequency: int(center_freq)
    samplerate: int(samp_rate)
    bandwidth: int(samp_rate)
    buffer_size: tx_buffer
    cyclic: 'False'
    attenuation1: tx_atten
    filter_source: '''Auto'''
  states: {}
- name: antsdr_rx
  id: iio_pluto_source
  parameters:
    type: fc32
    uri: uri
    frequency: int(center_freq)
    samplerate: int(samp_rate)
    bandwidth: int(samp_rate)
    buffer_size: '32768'
    gain1: '''manual'''
    manual_gain1: rx_gain
    quadrature: 'True'
    rfdc: 'True'
    bbdc: 'True'
    len_tag_key: ''
    filter_source: '''Auto'''
  states: {}

connections:
- [mac_tx, pdus, tx_stream, pdus]
- [tx_stream, '0', tx_crc, '0']
- [tx_crc, '0', tx_pdu, '0']
- [tx_pdu, pdus, ldpc_enc, pdus]
- [ldpc_enc, pdus, framer, pdus]
- [framer, pdus, lane0_select, pdus]
- [lane0_select, pdus, lane0_stream, pdus]
- [lane0_stream, '0', lane0_map, '0']
- [lane0_map, '0', lane0_repeat, '0']
- [lane0_repeat, '0', lane0_spread, '0']
- [lane0_code, '0', lane0_spread, '1']
- [lane0_spread, '0', lane0_len, '0']
- [lane0_len, '0', combiner, '0']
- [framer, pdus, lane1_select, pdus]
- [lane1_select, pdus, lane1_stream, pdus]
- [lane1_stream, '0', lane1_map, '0']
- [lane1_map, '0', lane1_repeat, '0']
- [lane1_repeat, '0', lane1_spread, '0']
- [lane1_code, '0', lane1_spread, '1']
- [lane1_spread, '0', lane1_len, '0']
- [lane1_len, '0', combiner, '1']
- [framer, pdus, lane2_select, pdus]
- [lane2_select, pdus, lane2_stream, pdus]
- [lane2_stream, '0', lane2_map, '0']
- [lane2_map, '0', lane2_repeat, '0']
- [lane2_repeat, '0', lane2_spread, '0']
- [lane2_code, '0', lane2_spread, '1']
- [lane2_spread, '0', lane2_len, '0']
- [lane2_len, '0', combiner, '2']
- [framer, pdus, lane3_select, pdus]
- [lane3_select, pdus, lane3_stream, pdus]
- [lane3_stream, '0', lane3_map, '0']
- [lane3_map, '0', lane3_repeat, '0']
- [lane3_repeat, '0', lane3_spread, '0']
- [lane3_code, '0', lane3_spread, '1']
- [lane3_spread, '0', lane3_len, '0']
- [lane3_len, '0', combiner, '3']
- [framer, pdus, lane4_select, pdus]
- [lane4_select, pdus, lane4_stream, pdus]
- [lane4_stream, '0', lane4_map, '0']
- [lane4_map, '0', lane4_repeat, '0']
- [lane4_repeat, '0', lane4_spread, '0']
- [lane4_code, '0', lane4_spread, '1']
- [lane4_spread, '0', lane4_len, '0']
- [lane4_len, '0', combiner, '4']
- [combiner, '0', tx_rrc, '0']
- [tx_rrc, '0', tx_gain, '0']
- [rx_mf, '0', despreader, '0']
- [despreader, pdus, rx_bpsk_select, pdus]
- [rx_bpsk_select, pdus, rx_bpsk_stream, pdus]
- [rx_bpsk_stream, '0', rx_bpsk_soft, '0']
- [rx_bpsk_soft, '0', rx_bpsk_len, '0']
- [rx_bpsk_len, '0', rx_bpsk_pdu, '0']
- [rx_bpsk_pdu, pdus, ldpc_dec, pdus]
- [despreader, pdus, rx_qpsk_select, pdus]
- [rx_qpsk_select, pdus, rx_qpsk_stream, pdus]
- [rx_qpsk_stream, '0', rx_qpsk_soft, '0']
- [rx_qpsk_soft, '0', rx_qpsk_len, '0']
- [rx_qpsk_len, '0', rx_qpsk_pdu, '0']
- [rx_qpsk_pdu, pdus, ldpc_dec, pdus]
- [despreader, pdus, rx_qam16_select, pdus]
- [rx_qam16_select, pdus, rx_qam16_stream, pdus]
- [rx_qam16_stream, '0', rx_qam16_soft, '0']
- [rx_qam16_soft, '0', rx_qam16_len, '0']
- [rx_qam16_len, '0', rx_qam16_pdu, '0']
- [rx_qam16_pdu, pdus, ldpc_dec, pdus]
- [ldpc_dec, pdus, rx_bytes, pdus]
- [rx_bytes, '0', rx_crc, '0']
- [rx_crc, '0', rx_pdu, '0']
- [rx_pdu, pdus, mac_rx, pdus]
- [tx_gain, '0', antsdr_tx, '0']
- [antsdr_rx, '0', rx_mf, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
